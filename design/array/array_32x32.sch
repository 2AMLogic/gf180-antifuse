C {devices/lab_pin.sym} 7280 6710 0 0 {name=l3784 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 6680 0 0 {name=Xc_29_18
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 6650 0 0 {name=l3785 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 6710 0 0 {name=l3786 sig_type=std_logic lab=WL_29_II}
C {devices/lab_pin.sym} 7680 6650 0 0 {name=l3787 sig_type=std_logic lab=PL_29_II}
C {devices/lab_pin.sym} 7680 6710 0 0 {name=l3788 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 6680 0 0 {name=Xc_29_19
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 6650 0 0 {name=l3789 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 6710 0 0 {name=l3790 sig_type=std_logic lab=WL_29_II}
C {devices/lab_pin.sym} 8080 6650 0 0 {name=l3791 sig_type=std_logic lab=PL_29_II}
C {devices/lab_pin.sym} 8080 6710 0 0 {name=l3792 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 6680 0 0 {name=Xc_29_20
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 6650 0 0 {name=l3793 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 6710 0 0 {name=l3794 sig_type=std_logic lab=WL_29_II}
C {devices/lab_pin.sym} 8480 6650 0 0 {name=l3795 sig_type=std_logic lab=PL_29_II}
C {devices/lab_pin.sym} 8480 6710 0 0 {name=l3796 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 6680 0 0 {name=Xc_29_21
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 6650 0 0 {name=l3797 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 6710 0 0 {name=l3798 sig_type=std_logic lab=WL_29_II}
C {devices/lab_pin.sym} 8880 6650 0 0 {name=l3799 sig_type=std_logic lab=PL_29_II}
C {devices/lab_pin.sym} 8880 6710 0 0 {name=l3800 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 6680 0 0 {name=Xc_29_22
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 6650 0 0 {name=l3801 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 6710 0 0 {name=l3802 sig_type=std_logic lab=WL_29_III}
C {devices/lab_pin.sym} 9280 6650 0 0 {name=l3803 sig_type=std_logic lab=PL_29_III}
C {devices/lab_pin.sym} 9280 6710 0 0 {name=l3804 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 6680 0 0 {name=Xc_29_23
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 6650 0 0 {name=l3805 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 6710 0 0 {name=l3806 sig_type=std_logic lab=WL_29_III}
C {devices/lab_pin.sym} 9680 6650 0 0 {name=l3807 sig_type=std_logic lab=PL_29_III}
C {devices/lab_pin.sym} 9680 6710 0 0 {name=l3808 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 6680 0 0 {name=Xc_29_24
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 6650 0 0 {name=l3809 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 6710 0 0 {name=l3810 sig_type=std_logic lab=WL_29_III}
C {devices/lab_pin.sym} 10080 6650 0 0 {name=l3811 sig_type=std_logic lab=PL_29_III}
C {devices/lab_pin.sym} 10080 6710 0 0 {name=l3812 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 6680 0 0 {name=Xc_29_25
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 6650 0 0 {name=l3813 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 6710 0 0 {name=l3814 sig_type=std_logic lab=WL_29_III}
C {devices/lab_pin.sym} 10480 6650 0 0 {name=l3815 sig_type=std_logic lab=PL_29_III}
C {devices/lab_pin.sym} 10480 6710 0 0 {name=l3816 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 6680 0 0 {name=Xc_29_26
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 6650 0 0 {name=l3817 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 6710 0 0 {name=l3818 sig_type=std_logic lab=WL_29_III}
C {devices/lab_pin.sym} 10880 6650 0 0 {name=l3819 sig_type=std_logic lab=PL_29_III}
C {devices/lab_pin.sym} 10880 6710 0 0 {name=l3820 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 6680 0 0 {name=Xc_29_27
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 6650 0 0 {name=l3821 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 6710 0 0 {name=l3822 sig_type=std_logic lab=WL_29_III}
C {devices/lab_pin.sym} 11280 6650 0 0 {name=l3823 sig_type=std_logic lab=PL_29_III}
C {devices/lab_pin.sym} 11280 6710 0 0 {name=l3824 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 6680 0 0 {name=Xc_29_28
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 6650 0 0 {name=l3825 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 6710 0 0 {name=l3826 sig_type=std_logic lab=WL_29_III}
C {devices/lab_pin.sym} 11680 6650 0 0 {name=l3827 sig_type=std_logic lab=PL_29_III}
C {devices/lab_pin.sym} 11680 6710 0 0 {name=l3828 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 6680 0 0 {name=Xc_29_29
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 6650 0 0 {name=l3829 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 6710 0 0 {name=l3830 sig_type=std_logic lab=WL_29_III}
C {devices/lab_pin.sym} 12080 6650 0 0 {name=l3831 sig_type=std_logic lab=PL_29_III}
C {devices/lab_pin.sym} 12080 6710 0 0 {name=l3832 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 6680 0 0 {name=Xc_29_30
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 6650 0 0 {name=l3833 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 6710 0 0 {name=l3834 sig_type=std_logic lab=WL_29_III}
C {devices/lab_pin.sym} 12480 6650 0 0 {name=l3835 sig_type=std_logic lab=PL_29_III}
C {devices/lab_pin.sym} 12480 6710 0 0 {name=l3836 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 6680 0 0 {name=Xc_29_31
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 6650 0 0 {name=l3837 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 6710 0 0 {name=l3838 sig_type=std_logic lab=WL_29_III}
C {devices/lab_pin.sym} 12880 6650 0 0 {name=l3839 sig_type=std_logic lab=PL_29_III}
C {devices/lab_pin.sym} 12880 6710 0 0 {name=l3840 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 6900 0 0 {name=Xc_30_0
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 6870 0 0 {name=l3841 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 6930 0 0 {name=l3842 sig_type=std_logic lab=WL_30_I}
C {devices/lab_pin.sym} 480 6870 0 0 {name=l3843 sig_type=std_logic lab=PL_30_I}
C {devices/lab_pin.sym} 480 6930 0 0 {name=l3844 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 6900 0 0 {name=Xc_30_1
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 6870 0 0 {name=l3845 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 6930 0 0 {name=l3846 sig_type=std_logic lab=WL_30_I}
C {devices/lab_pin.sym} 880 6870 0 0 {name=l3847 sig_type=std_logic lab=PL_30_I}
C {devices/lab_pin.sym} 880 6930 0 0 {name=l3848 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 6900 0 0 {name=Xc_30_2
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 6870 0 0 {name=l3849 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 6930 0 0 {name=l3850 sig_type=std_logic lab=WL_30_I}
C {devices/lab_pin.sym} 1280 6870 0 0 {name=l3851 sig_type=std_logic lab=PL_30_I}
C {devices/lab_pin.sym} 1280 6930 0 0 {name=l3852 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 6900 0 0 {name=Xc_30_3
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 6870 0 0 {name=l3853 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 6930 0 0 {name=l3854 sig_type=std_logic lab=WL_30_I}
C {devices/lab_pin.sym} 1680 6870 0 0 {name=l3855 sig_type=std_logic lab=PL_30_I}
C {devices/lab_pin.sym} 1680 6930 0 0 {name=l3856 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 6900 0 0 {name=Xc_30_4
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 6870 0 0 {name=l3857 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 6930 0 0 {name=l3858 sig_type=std_logic lab=WL_30_I}
C {devices/lab_pin.sym} 2080 6870 0 0 {name=l3859 sig_type=std_logic lab=PL_30_I}
C {devices/lab_pin.sym} 2080 6930 0 0 {name=l3860 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 6900 0 0 {name=Xc_30_5
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 6870 0 0 {name=l3861 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 6930 0 0 {name=l3862 sig_type=std_logic lab=WL_30_I}
C {devices/lab_pin.sym} 2480 6870 0 0 {name=l3863 sig_type=std_logic lab=PL_30_I}
C {devices/lab_pin.sym} 2480 6930 0 0 {name=l3864 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 6900 0 0 {name=Xc_30_6
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 6870 0 0 {name=l3865 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 6930 0 0 {name=l3866 sig_type=std_logic lab=WL_30_I}
C {devices/lab_pin.sym} 2880 6870 0 0 {name=l3867 sig_type=std_logic lab=PL_30_I}
C {devices/lab_pin.sym} 2880 6930 0 0 {name=l3868 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 6900 0 0 {name=Xc_30_7
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 6870 0 0 {name=l3869 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 6930 0 0 {name=l3870 sig_type=std_logic lab=WL_30_I}
C {devices/lab_pin.sym} 3280 6870 0 0 {name=l3871 sig_type=std_logic lab=PL_30_I}
C {devices/lab_pin.sym} 3280 6930 0 0 {name=l3872 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 6900 0 0 {name=Xc_30_8
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 6870 0 0 {name=l3873 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 6930 0 0 {name=l3874 sig_type=std_logic lab=WL_30_I}
C {devices/lab_pin.sym} 3680 6870 0 0 {name=l3875 sig_type=std_logic lab=PL_30_I}
C {devices/lab_pin.sym} 3680 6930 0 0 {name=l3876 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 6900 0 0 {name=Xc_30_9
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 6870 0 0 {name=l3877 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 6930 0 0 {name=l3878 sig_type=std_logic lab=WL_30_I}
C {devices/lab_pin.sym} 4080 6870 0 0 {name=l3879 sig_type=std_logic lab=PL_30_I}
C {devices/lab_pin.sym} 4080 6930 0 0 {name=l3880 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 6900 0 0 {name=Xc_30_10
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 6870 0 0 {name=l3881 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 6930 0 0 {name=l3882 sig_type=std_logic lab=WL_30_I}
C {devices/lab_pin.sym} 4480 6870 0 0 {name=l3883 sig_type=std_logic lab=PL_30_I}
C {devices/lab_pin.sym} 4480 6930 0 0 {name=l3884 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 6900 0 0 {name=Xc_30_11
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 6870 0 0 {name=l3885 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 6930 0 0 {name=l3886 sig_type=std_logic lab=WL_30_II}
C {devices/lab_pin.sym} 4880 6870 0 0 {name=l3887 sig_type=std_logic lab=PL_30_II}
C {devices/lab_pin.sym} 4880 6930 0 0 {name=l3888 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 6900 0 0 {name=Xc_30_12
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 6870 0 0 {name=l3889 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 6930 0 0 {name=l3890 sig_type=std_logic lab=WL_30_II}
C {devices/lab_pin.sym} 5280 6870 0 0 {name=l3891 sig_type=std_logic lab=PL_30_II}
C {devices/lab_pin.sym} 5280 6930 0 0 {name=l3892 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 6900 0 0 {name=Xc_30_13
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 6870 0 0 {name=l3893 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 6930 0 0 {name=l3894 sig_type=std_logic lab=WL_30_II}
C {devices/lab_pin.sym} 5680 6870 0 0 {name=l3895 sig_type=std_logic lab=PL_30_II}
C {devices/lab_pin.sym} 5680 6930 0 0 {name=l3896 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 6900 0 0 {name=Xc_30_14
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 6870 0 0 {name=l3897 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 6930 0 0 {name=l3898 sig_type=std_logic lab=WL_30_II}
C {devices/lab_pin.sym} 6080 6870 0 0 {name=l3899 sig_type=std_logic lab=PL_30_II}
C {devices/lab_pin.sym} 6080 6930 0 0 {name=l3900 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 6900 0 0 {name=Xc_30_15
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 6870 0 0 {name=l3901 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 6930 0 0 {name=l3902 sig_type=std_logic lab=WL_30_II}
C {devices/lab_pin.sym} 6480 6870 0 0 {name=l3903 sig_type=std_logic lab=PL_30_II}
C {devices/lab_pin.sym} 6480 6930 0 0 {name=l3904 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 6900 0 0 {name=Xc_30_16
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 6870 0 0 {name=l3905 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 6930 0 0 {name=l3906 sig_type=std_logic lab=WL_30_II}
C {devices/lab_pin.sym} 6880 6870 0 0 {name=l3907 sig_type=std_logic lab=PL_30_II}
C {devices/lab_pin.sym} 6880 6930 0 0 {name=l3908 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 6900 0 0 {name=Xc_30_17
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 6870 0 0 {name=l3909 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 6930 0 0 {name=l3910 sig_type=std_logic lab=WL_30_II}
C {devices/lab_pin.sym} 7280 6870 0 0 {name=l3911 sig_type=std_logic lab=PL_30_II}
C {devices/lab_pin.sym} 7280 6930 0 0 {name=l3912 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 6900 0 0 {name=Xc_30_18
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 6870 0 0 {name=l3913 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 6930 0 0 {name=l3914 sig_type=std_logic lab=WL_30_II}
C {devices/lab_pin.sym} 7680 6870 0 0 {name=l3915 sig_type=std_logic lab=PL_30_II}
C {devices/lab_pin.sym} 7680 6930 0 0 {name=l3916 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 6900 0 0 {name=Xc_30_19
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 6870 0 0 {name=l3917 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 6930 0 0 {name=l3918 sig_type=std_logic lab=WL_30_II}
C {devices/lab_pin.sym} 8080 6870 0 0 {name=l3919 sig_type=std_logic lab=PL_30_II}
C {devices/lab_pin.sym} 8080 6930 0 0 {name=l3920 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 6900 0 0 {name=Xc_30_20
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 6870 0 0 {name=l3921 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 6930 0 0 {name=l3922 sig_type=std_logic lab=WL_30_II}
C {devices/lab_pin.sym} 8480 6870 0 0 {name=l3923 sig_type=std_logic lab=PL_30_II}
C {devices/lab_pin.sym} 8480 6930 0 0 {name=l3924 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 6900 0 0 {name=Xc_30_21
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 6870 0 0 {name=l3925 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 6930 0 0 {name=l3926 sig_type=std_logic lab=WL_30_II}
C {devices/lab_pin.sym} 8880 6870 0 0 {name=l3927 sig_type=std_logic lab=PL_30_II}
C {devices/lab_pin.sym} 8880 6930 0 0 {name=l3928 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 6900 0 0 {name=Xc_30_22
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 6870 0 0 {name=l3929 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 6930 0 0 {name=l3930 sig_type=std_logic lab=WL_30_III}
C {devices/lab_pin.sym} 9280 6870 0 0 {name=l3931 sig_type=std_logic lab=PL_30_III}
C {devices/lab_pin.sym} 9280 6930 0 0 {name=l3932 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 6900 0 0 {name=Xc_30_23
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 6870 0 0 {name=l3933 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 6930 0 0 {name=l3934 sig_type=std_logic lab=WL_30_III}
C {devices/lab_pin.sym} 9680 6870 0 0 {name=l3935 sig_type=std_logic lab=PL_30_III}
C {devices/lab_pin.sym} 9680 6930 0 0 {name=l3936 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 6900 0 0 {name=Xc_30_24
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 6870 0 0 {name=l3937 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 6930 0 0 {name=l3938 sig_type=std_logic lab=WL_30_III}
C {devices/lab_pin.sym} 10080 6870 0 0 {name=l3939 sig_type=std_logic lab=PL_30_III}
C {devices/lab_pin.sym} 10080 6930 0 0 {name=l3940 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 6900 0 0 {name=Xc_30_25
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 6870 0 0 {name=l3941 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 6930 0 0 {name=l3942 sig_type=std_logic lab=WL_30_III}
C {devices/lab_pin.sym} 10480 6870 0 0 {name=l3943 sig_type=std_logic lab=PL_30_III}
C {devices/lab_pin.sym} 10480 6930 0 0 {name=l3944 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 6900 0 0 {name=Xc_30_26
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 6870 0 0 {name=l3945 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 6930 0 0 {name=l3946 sig_type=std_logic lab=WL_30_III}
C {devices/lab_pin.sym} 10880 6870 0 0 {name=l3947 sig_type=std_logic lab=PL_30_III}
C {devices/lab_pin.sym} 10880 6930 0 0 {name=l3948 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 6900 0 0 {name=Xc_30_27
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 6870 0 0 {name=l3949 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 6930 0 0 {name=l3950 sig_type=std_logic lab=WL_30_III}
C {devices/lab_pin.sym} 11280 6870 0 0 {name=l3951 sig_type=std_logic lab=PL_30_III}
C {devices/lab_pin.sym} 11280 6930 0 0 {name=l3952 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 6900 0 0 {name=Xc_30_28
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 6870 0 0 {name=l3953 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 6930 0 0 {name=l3954 sig_type=std_logic lab=WL_30_III}
C {devices/lab_pin.sym} 11680 6870 0 0 {name=l3955 sig_type=std_logic lab=PL_30_III}
C {devices/lab_pin.sym} 11680 6930 0 0 {name=l3956 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 6900 0 0 {name=Xc_30_29
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 6870 0 0 {name=l3957 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 6930 0 0 {name=l3958 sig_type=std_logic lab=WL_30_III}
C {devices/lab_pin.sym} 12080 6870 0 0 {name=l3959 sig_type=std_logic lab=PL_30_III}
C {devices/lab_pin.sym} 12080 6930 0 0 {name=l3960 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 6900 0 0 {name=Xc_30_30
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 6870 0 0 {name=l3961 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 6930 0 0 {name=l3962 sig_type=std_logic lab=WL_30_III}
C {devices/lab_pin.sym} 12480 6870 0 0 {name=l3963 sig_type=std_logic lab=PL_30_III}
C {devices/lab_pin.sym} 12480 6930 0 0 {name=l3964 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 6900 0 0 {name=Xc_30_31
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 6870 0 0 {name=l3965 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 6930 0 0 {name=l3966 sig_type=std_logic lab=WL_30_III}
C {devices/lab_pin.sym} 12880 6870 0 0 {name=l3967 sig_type=std_logic lab=PL_30_III}
C {devices/lab_pin.sym} 12880 6930 0 0 {name=l3968 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 7120 0 0 {name=Xc_31_0
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 7090 0 0 {name=l3969 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 7150 0 0 {name=l3970 sig_type=std_logic lab=WL_31_I}
C {devices/lab_pin.sym} 480 7090 0 0 {name=l3971 sig_type=std_logic lab=PL_31_I}
C {devices/lab_pin.sym} 480 7150 0 0 {name=l3972 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 7120 0 0 {name=Xc_31_1
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 7090 0 0 {name=l3973 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 7150 0 0 {name=l3974 sig_type=std_logic lab=WL_31_I}
C {devices/lab_pin.sym} 880 7090 0 0 {name=l3975 sig_type=std_logic lab=PL_31_I}
C {devices/lab_pin.sym} 880 7150 0 0 {name=l3976 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 7120 0 0 {name=Xc_31_2
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 7090 0 0 {name=l3977 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 7150 0 0 {name=l3978 sig_type=std_logic lab=WL_31_I}
C {devices/lab_pin.sym} 1280 7090 0 0 {name=l3979 sig_type=std_logic lab=PL_31_I}
C {devices/lab_pin.sym} 1280 7150 0 0 {name=l3980 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 7120 0 0 {name=Xc_31_3
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 7090 0 0 {name=l3981 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 7150 0 0 {name=l3982 sig_type=std_logic lab=WL_31_I}
C {devices/lab_pin.sym} 1680 7090 0 0 {name=l3983 sig_type=std_logic lab=PL_31_I}
C {devices/lab_pin.sym} 1680 7150 0 0 {name=l3984 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 7120 0 0 {name=Xc_31_4
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 7090 0 0 {name=l3985 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 7150 0 0 {name=l3986 sig_type=std_logic lab=WL_31_I}
C {devices/lab_pin.sym} 2080 7090 0 0 {name=l3987 sig_type=std_logic lab=PL_31_I}
C {devices/lab_pin.sym} 2080 7150 0 0 {name=l3988 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 7120 0 0 {name=Xc_31_5
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 7090 0 0 {name=l3989 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 7150 0 0 {name=l3990 sig_type=std_logic lab=WL_31_I}
C {devices/lab_pin.sym} 2480 7090 0 0 {name=l3991 sig_type=std_logic lab=PL_31_I}
C {devices/lab_pin.sym} 2480 7150 0 0 {name=l3992 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 7120 0 0 {name=Xc_31_6
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 7090 0 0 {name=l3993 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 7150 0 0 {name=l3994 sig_type=std_logic lab=WL_31_I}
C {devices/lab_pin.sym} 2880 7090 0 0 {name=l3995 sig_type=std_logic lab=PL_31_I}
C {devices/lab_pin.sym} 2880 7150 0 0 {name=l3996 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 7120 0 0 {name=Xc_31_7
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 7090 0 0 {name=l3997 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 7150 0 0 {name=l3998 sig_type=std_logic lab=WL_31_I}
C {devices/lab_pin.sym} 3280 7090 0 0 {name=l3999 sig_type=std_logic lab=PL_31_I}
C {devices/lab_pin.sym} 3280 7150 0 0 {name=l4000 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 7120 0 0 {name=Xc_31_8
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 7090 0 0 {name=l4001 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 7150 0 0 {name=l4002 sig_type=std_logic lab=WL_31_I}
C {devices/lab_pin.sym} 3680 7090 0 0 {name=l4003 sig_type=std_logic lab=PL_31_I}
C {devices/lab_pin.sym} 3680 7150 0 0 {name=l4004 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 7120 0 0 {name=Xc_31_9
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 7090 0 0 {name=l4005 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 7150 0 0 {name=l4006 sig_type=std_logic lab=WL_31_I}
C {devices/lab_pin.sym} 4080 7090 0 0 {name=l4007 sig_type=std_logic lab=PL_31_I}
C {devices/lab_pin.sym} 4080 7150 0 0 {name=l4008 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 7120 0 0 {name=Xc_31_10
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 7090 0 0 {name=l4009 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 7150 0 0 {name=l4010 sig_type=std_logic lab=WL_31_I}
C {devices/lab_pin.sym} 4480 7090 0 0 {name=l4011 sig_type=std_logic lab=PL_31_I}
C {devices/lab_pin.sym} 4480 7150 0 0 {name=l4012 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 7120 0 0 {name=Xc_31_11
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 7090 0 0 {name=l4013 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 7150 0 0 {name=l4014 sig_type=std_logic lab=WL_31_II}
C {devices/lab_pin.sym} 4880 7090 0 0 {name=l4015 sig_type=std_logic lab=PL_31_II}
C {devices/lab_pin.sym} 4880 7150 0 0 {name=l4016 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 7120 0 0 {name=Xc_31_12
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 7090 0 0 {name=l4017 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 7150 0 0 {name=l4018 sig_type=std_logic lab=WL_31_II}
C {devices/lab_pin.sym} 5280 7090 0 0 {name=l4019 sig_type=std_logic lab=PL_31_II}
C {devices/lab_pin.sym} 5280 7150 0 0 {name=l4020 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 7120 0 0 {name=Xc_31_13
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 7090 0 0 {name=l4021 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 7150 0 0 {name=l4022 sig_type=std_logic lab=WL_31_II}
C {devices/lab_pin.sym} 5680 7090 0 0 {name=l4023 sig_type=std_logic lab=PL_31_II}
C {devices/lab_pin.sym} 5680 7150 0 0 {name=l4024 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 7120 0 0 {name=Xc_31_14
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 7090 0 0 {name=l4025 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 7150 0 0 {name=l4026 sig_type=std_logic lab=WL_31_II}
C {devices/lab_pin.sym} 6080 7090 0 0 {name=l4027 sig_type=std_logic lab=PL_31_II}
C {devices/lab_pin.sym} 6080 7150 0 0 {name=l4028 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 7120 0 0 {name=Xc_31_15
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 7090 0 0 {name=l4029 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 7150 0 0 {name=l4030 sig_type=std_logic lab=WL_31_II}
C {devices/lab_pin.sym} 6480 7090 0 0 {name=l4031 sig_type=std_logic lab=PL_31_II}
C {devices/lab_pin.sym} 6480 7150 0 0 {name=l4032 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 7120 0 0 {name=Xc_31_16
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 7090 0 0 {name=l4033 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 7150 0 0 {name=l4034 sig_type=std_logic lab=WL_31_II}
C {devices/lab_pin.sym} 6880 7090 0 0 {name=l4035 sig_type=std_logic lab=PL_31_II}
C {devices/lab_pin.sym} 6880 7150 0 0 {name=l4036 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 7120 0 0 {name=Xc_31_17
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 7090 0 0 {name=l4037 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 7150 0 0 {name=l4038 sig_type=std_logic lab=WL_31_II}
C {devices/lab_pin.sym} 7280 7090 0 0 {name=l4039 sig_type=std_logic lab=PL_31_II}
C {devices/lab_pin.sym} 7280 7150 0 0 {name=l4040 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 7120 0 0 {name=Xc_31_18
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 7090 0 0 {name=l4041 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 7150 0 0 {name=l4042 sig_type=std_logic lab=WL_31_II}
C {devices/lab_pin.sym} 7680 7090 0 0 {name=l4043 sig_type=std_logic lab=PL_31_II}
C {devices/lab_pin.sym} 7680 7150 0 0 {name=l4044 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 7120 0 0 {name=Xc_31_19
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 7090 0 0 {name=l4045 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 7150 0 0 {name=l4046 sig_type=std_logic lab=WL_31_II}
C {devices/lab_pin.sym} 8080 7090 0 0 {name=l4047 sig_type=std_logic lab=PL_31_II}
C {devices/lab_pin.sym} 8080 7150 0 0 {name=l4048 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 7120 0 0 {name=Xc_31_20
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 7090 0 0 {name=l4049 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 7150 0 0 {name=l4050 sig_type=std_logic lab=WL_31_II}
C {devices/lab_pin.sym} 8480 7090 0 0 {name=l4051 sig_type=std_logic lab=PL_31_II}
C {devices/lab_pin.sym} 8480 7150 0 0 {name=l4052 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 7120 0 0 {name=Xc_31_21
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 7090 0 0 {name=l4053 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 7150 0 0 {name=l4054 sig_type=std_logic lab=WL_31_II}
C {devices/lab_pin.sym} 8880 7090 0 0 {name=l4055 sig_type=std_logic lab=PL_31_II}
C {devices/lab_pin.sym} 8880 7150 0 0 {name=l4056 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 7120 0 0 {name=Xc_31_22
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 7090 0 0 {name=l4057 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 7150 0 0 {name=l4058 sig_type=std_logic lab=WL_31_III}
C {devices/lab_pin.sym} 9280 7090 0 0 {name=l4059 sig_type=std_logic lab=PL_31_III}
C {devices/lab_pin.sym} 9280 7150 0 0 {name=l4060 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 7120 0 0 {name=Xc_31_23
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 7090 0 0 {name=l4061 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 7150 0 0 {name=l4062 sig_type=std_logic lab=WL_31_III}
C {devices/lab_pin.sym} 9680 7090 0 0 {name=l4063 sig_type=std_logic lab=PL_31_III}
C {devices/lab_pin.sym} 9680 7150 0 0 {name=l4064 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 7120 0 0 {name=Xc_31_24
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 7090 0 0 {name=l4065 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 7150 0 0 {name=l4066 sig_type=std_logic lab=WL_31_III}
C {devices/lab_pin.sym} 10080 7090 0 0 {name=l4067 sig_type=std_logic lab=PL_31_III}
C {devices/lab_pin.sym} 10080 7150 0 0 {name=l4068 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 7120 0 0 {name=Xc_31_25
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 7090 0 0 {name=l4069 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 7150 0 0 {name=l4070 sig_type=std_logic lab=WL_31_III}
C {devices/lab_pin.sym} 10480 7090 0 0 {name=l4071 sig_type=std_logic lab=PL_31_III}
C {devices/lab_pin.sym} 10480 7150 0 0 {name=l4072 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 7120 0 0 {name=Xc_31_26
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 7090 0 0 {name=l4073 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 7150 0 0 {name=l4074 sig_type=std_logic lab=WL_31_III}
C {devices/lab_pin.sym} 10880 7090 0 0 {name=l4075 sig_type=std_logic lab=PL_31_III}
C {devices/lab_pin.sym} 10880 7150 0 0 {name=l4076 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 7120 0 0 {name=Xc_31_27
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 7090 0 0 {name=l4077 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 7150 0 0 {name=l4078 sig_type=std_logic lab=WL_31_III}
C {devices/lab_pin.sym} 11280 7090 0 0 {name=l4079 sig_type=std_logic lab=PL_31_III}
C {devices/lab_pin.sym} 11280 7150 0 0 {name=l4080 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 7120 0 0 {name=Xc_31_28
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 7090 0 0 {name=l4081 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 7150 0 0 {name=l4082 sig_type=std_logic lab=WL_31_III}
C {devices/lab_pin.sym} 11680 7090 0 0 {name=l4083 sig_type=std_logic lab=PL_31_III}
C {devices/lab_pin.sym} 11680 7150 0 0 {name=l4084 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 7120 0 0 {name=Xc_31_29
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 7090 0 0 {name=l4085 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 7150 0 0 {name=l4086 sig_type=std_logic lab=WL_31_III}
C {devices/lab_pin.sym} 12080 7090 0 0 {name=l4087 sig_type=std_logic lab=PL_31_III}
C {devices/lab_pin.sym} 12080 7150 0 0 {name=l4088 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 7120 0 0 {name=Xc_31_30
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 7090 0 0 {name=l4089 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 7150 0 0 {name=l4090 sig_type=std_logic lab=WL_31_III}
C {devices/lab_pin.sym} 12480 7090 0 0 {name=l4091 sig_type=std_logic lab=PL_31_III}
C {devices/lab_pin.sym} 12480 7150 0 0 {name=l4092 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 7120 0 0 {name=Xc_31_31
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 7090 0 0 {name=l4093 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 7150 0 0 {name=l4094 sig_type=std_logic lab=WL_31_III}
C {devices/lab_pin.sym} 12880 7090 0 0 {name=l4095 sig_type=std_logic lab=PL_31_III}
C {devices/lab_pin.sym} 12880 7150 0 0 {name=l4096 sig_type=std_logic lab=VDDH_III}
C {ls_hv06.sym} 400 7440 0 0 {name=XLC_0}
C {devices/lab_pin.sym} 320 7420 0 0 {name=l4097 sig_type=std_logic lab=CSEL_0}
C {devices/lab_pin.sym} 320 7440 0 0 {name=l4098 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 320 7460 0 0 {name=l4099 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 480 7420 0 0 {name=l4100 sig_type=std_logic lab=CG_0}
C {devices/lab_pin.sym} 480 7440 0 0 {name=l4101 sig_type=std_logic lab=CGB_0}
C {devices/lab_pin.sym} 480 7460 0 0 {name=l4102 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 400 7640 0 0 {name=XPC_0}
C {devices/lab_pin.sym} 320 7630 0 0 {name=l4103 sig_type=std_logic lab=BLG_I}
C {devices/lab_pin.sym} 320 7650 0 0 {name=l4104 sig_type=std_logic lab=CG_0}
C {devices/lab_pin.sym} 480 7630 0 0 {name=l4105 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 480 7650 0 0 {name=l4106 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 800 7440 0 0 {name=XLC_1}
C {devices/lab_pin.sym} 720 7420 0 0 {name=l4107 sig_type=std_logic lab=CSEL_1}
C {devices/lab_pin.sym} 720 7440 0 0 {name=l4108 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 720 7460 0 0 {name=l4109 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 880 7420 0 0 {name=l4110 sig_type=std_logic lab=CG_1}
C {devices/lab_pin.sym} 880 7440 0 0 {name=l4111 sig_type=std_logic lab=CGB_1}
C {devices/lab_pin.sym} 880 7460 0 0 {name=l4112 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 800 7640 0 0 {name=XPC_1}
C {devices/lab_pin.sym} 720 7630 0 0 {name=l4113 sig_type=std_logic lab=BLG_I}
C {devices/lab_pin.sym} 720 7650 0 0 {name=l4114 sig_type=std_logic lab=CG_1}
C {devices/lab_pin.sym} 880 7630 0 0 {name=l4115 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 880 7650 0 0 {name=l4116 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 1200 7440 0 0 {name=XLC_2}
C {devices/lab_pin.sym} 1120 7420 0 0 {name=l4117 sig_type=std_logic lab=CSEL_2}
C {devices/lab_pin.sym} 1120 7440 0 0 {name=l4118 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 1120 7460 0 0 {name=l4119 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1280 7420 0 0 {name=l4120 sig_type=std_logic lab=CG_2}
C {devices/lab_pin.sym} 1280 7440 0 0 {name=l4121 sig_type=std_logic lab=CGB_2}
C {devices/lab_pin.sym} 1280 7460 0 0 {name=l4122 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 1200 7640 0 0 {name=XPC_2}
C {devices/lab_pin.sym} 1120 7630 0 0 {name=l4123 sig_type=std_logic lab=BLG_I}
C {devices/lab_pin.sym} 1120 7650 0 0 {name=l4124 sig_type=std_logic lab=CG_2}
C {devices/lab_pin.sym} 1280 7630 0 0 {name=l4125 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1280 7650 0 0 {name=l4126 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 1600 7440 0 0 {name=XLC_3}
C {devices/lab_pin.sym} 1520 7420 0 0 {name=l4127 sig_type=std_logic lab=CSEL_3}
C {devices/lab_pin.sym} 1520 7440 0 0 {name=l4128 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 1520 7460 0 0 {name=l4129 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1680 7420 0 0 {name=l4130 sig_type=std_logic lab=CG_3}
C {devices/lab_pin.sym} 1680 7440 0 0 {name=l4131 sig_type=std_logic lab=CGB_3}
C {devices/lab_pin.sym} 1680 7460 0 0 {name=l4132 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 1600 7640 0 0 {name=XPC_3}
C {devices/lab_pin.sym} 1520 7630 0 0 {name=l4133 sig_type=std_logic lab=BLG_I}
C {devices/lab_pin.sym} 1520 7650 0 0 {name=l4134 sig_type=std_logic lab=CG_3}
C {devices/lab_pin.sym} 1680 7630 0 0 {name=l4135 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1680 7650 0 0 {name=l4136 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 2000 7440 0 0 {name=XLC_4}
C {devices/lab_pin.sym} 1920 7420 0 0 {name=l4137 sig_type=std_logic lab=CSEL_4}
C {devices/lab_pin.sym} 1920 7440 0 0 {name=l4138 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 1920 7460 0 0 {name=l4139 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2080 7420 0 0 {name=l4140 sig_type=std_logic lab=CG_4}
C {devices/lab_pin.sym} 2080 7440 0 0 {name=l4141 sig_type=std_logic lab=CGB_4}
C {devices/lab_pin.sym} 2080 7460 0 0 {name=l4142 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 2000 7640 0 0 {name=XPC_4}
C {devices/lab_pin.sym} 1920 7630 0 0 {name=l4143 sig_type=std_logic lab=BLG_I}
C {devices/lab_pin.sym} 1920 7650 0 0 {name=l4144 sig_type=std_logic lab=CG_4}
C {devices/lab_pin.sym} 2080 7630 0 0 {name=l4145 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 2080 7650 0 0 {name=l4146 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 2400 7440 0 0 {name=XLC_5}
C {devices/lab_pin.sym} 2320 7420 0 0 {name=l4147 sig_type=std_logic lab=CSEL_5}
C {devices/lab_pin.sym} 2320 7440 0 0 {name=l4148 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 2320 7460 0 0 {name=l4149 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2480 7420 0 0 {name=l4150 sig_type=std_logic lab=CG_5}
C {devices/lab_pin.sym} 2480 7440 0 0 {name=l4151 sig_type=std_logic lab=CGB_5}
C {devices/lab_pin.sym} 2480 7460 0 0 {name=l4152 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 2400 7640 0 0 {name=XPC_5}
C {devices/lab_pin.sym} 2320 7630 0 0 {name=l4153 sig_type=std_logic lab=BLG_I}
C {devices/lab_pin.sym} 2320 7650 0 0 {name=l4154 sig_type=std_logic lab=CG_5}
C {devices/lab_pin.sym} 2480 7630 0 0 {name=l4155 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2480 7650 0 0 {name=l4156 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 2800 7440 0 0 {name=XLC_6}
C {devices/lab_pin.sym} 2720 7420 0 0 {name=l4157 sig_type=std_logic lab=CSEL_6}
C {devices/lab_pin.sym} 2720 7440 0 0 {name=l4158 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 2720 7460 0 0 {name=l4159 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2880 7420 0 0 {name=l4160 sig_type=std_logic lab=CG_6}
C {devices/lab_pin.sym} 2880 7440 0 0 {name=l4161 sig_type=std_logic lab=CGB_6}
C {devices/lab_pin.sym} 2880 7460 0 0 {name=l4162 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 2800 7640 0 0 {name=XPC_6}
C {devices/lab_pin.sym} 2720 7630 0 0 {name=l4163 sig_type=std_logic lab=BLG_I}
C {devices/lab_pin.sym} 2720 7650 0 0 {name=l4164 sig_type=std_logic lab=CG_6}
C {devices/lab_pin.sym} 2880 7630 0 0 {name=l4165 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2880 7650 0 0 {name=l4166 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 3200 7440 0 0 {name=XLC_7}
C {devices/lab_pin.sym} 3120 7420 0 0 {name=l4167 sig_type=std_logic lab=CSEL_7}
C {devices/lab_pin.sym} 3120 7440 0 0 {name=l4168 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 3120 7460 0 0 {name=l4169 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3280 7420 0 0 {name=l4170 sig_type=std_logic lab=CG_7}
C {devices/lab_pin.sym} 3280 7440 0 0 {name=l4171 sig_type=std_logic lab=CGB_7}
C {devices/lab_pin.sym} 3280 7460 0 0 {name=l4172 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 3200 7640 0 0 {name=XPC_7}
C {devices/lab_pin.sym} 3120 7630 0 0 {name=l4173 sig_type=std_logic lab=BLG_I}
C {devices/lab_pin.sym} 3120 7650 0 0 {name=l4174 sig_type=std_logic lab=CG_7}
C {devices/lab_pin.sym} 3280 7630 0 0 {name=l4175 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3280 7650 0 0 {name=l4176 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 3600 7440 0 0 {name=XLC_8}
C {devices/lab_pin.sym} 3520 7420 0 0 {name=l4177 sig_type=std_logic lab=CSEL_8}
C {devices/lab_pin.sym} 3520 7440 0 0 {name=l4178 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 3520 7460 0 0 {name=l4179 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3680 7420 0 0 {name=l4180 sig_type=std_logic lab=CG_8}
C {devices/lab_pin.sym} 3680 7440 0 0 {name=l4181 sig_type=std_logic lab=CGB_8}
C {devices/lab_pin.sym} 3680 7460 0 0 {name=l4182 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 3600 7640 0 0 {name=XPC_8}
C {devices/lab_pin.sym} 3520 7630 0 0 {name=l4183 sig_type=std_logic lab=BLG_I}
C {devices/lab_pin.sym} 3520 7650 0 0 {name=l4184 sig_type=std_logic lab=CG_8}
C {devices/lab_pin.sym} 3680 7630 0 0 {name=l4185 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3680 7650 0 0 {name=l4186 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 4000 7440 0 0 {name=XLC_9}
C {devices/lab_pin.sym} 3920 7420 0 0 {name=l4187 sig_type=std_logic lab=CSEL_9}
C {devices/lab_pin.sym} 3920 7440 0 0 {name=l4188 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 3920 7460 0 0 {name=l4189 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4080 7420 0 0 {name=l4190 sig_type=std_logic lab=CG_9}
C {devices/lab_pin.sym} 4080 7440 0 0 {name=l4191 sig_type=std_logic lab=CGB_9}
C {devices/lab_pin.sym} 4080 7460 0 0 {name=l4192 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 4000 7640 0 0 {name=XPC_9}
C {devices/lab_pin.sym} 3920 7630 0 0 {name=l4193 sig_type=std_logic lab=BLG_I}
C {devices/lab_pin.sym} 3920 7650 0 0 {name=l4194 sig_type=std_logic lab=CG_9}
C {devices/lab_pin.sym} 4080 7630 0 0 {name=l4195 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 4080 7650 0 0 {name=l4196 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 4400 7440 0 0 {name=XLC_10}
C {devices/lab_pin.sym} 4320 7420 0 0 {name=l4197 sig_type=std_logic lab=CSEL_10}
C {devices/lab_pin.sym} 4320 7440 0 0 {name=l4198 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 4320 7460 0 0 {name=l4199 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4480 7420 0 0 {name=l4200 sig_type=std_logic lab=CG_10}
C {devices/lab_pin.sym} 4480 7440 0 0 {name=l4201 sig_type=std_logic lab=CGB_10}
C {devices/lab_pin.sym} 4480 7460 0 0 {name=l4202 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 4400 7640 0 0 {name=XPC_10}
C {devices/lab_pin.sym} 4320 7630 0 0 {name=l4203 sig_type=std_logic lab=BLG_I}
C {devices/lab_pin.sym} 4320 7650 0 0 {name=l4204 sig_type=std_logic lab=CG_10}
C {devices/lab_pin.sym} 4480 7630 0 0 {name=l4205 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4480 7650 0 0 {name=l4206 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} 4800 7440 0 0 {name=XLC_11}
C {devices/lab_pin.sym} 4720 7420 0 0 {name=l4207 sig_type=std_logic lab=CSEL_11}
C {devices/lab_pin.sym} 4720 7440 0 0 {name=l4208 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 4720 7460 0 0 {name=l4209 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4880 7420 0 0 {name=l4210 sig_type=std_logic lab=CG_11}
C {devices/lab_pin.sym} 4880 7440 0 0 {name=l4211 sig_type=std_logic lab=CGB_11}
C {devices/lab_pin.sym} 4880 7460 0 0 {name=l4212 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} 4800 7640 0 0 {name=XPC_11}
C {devices/lab_pin.sym} 4720 7630 0 0 {name=l4213 sig_type=std_logic lab=BLG_II}
C {devices/lab_pin.sym} 4720 7650 0 0 {name=l4214 sig_type=std_logic lab=CG_11}
C {devices/lab_pin.sym} 4880 7630 0 0 {name=l4215 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4880 7650 0 0 {name=l4216 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} 5200 7440 0 0 {name=XLC_12}
C {devices/lab_pin.sym} 5120 7420 0 0 {name=l4217 sig_type=std_logic lab=CSEL_12}
C {devices/lab_pin.sym} 5120 7440 0 0 {name=l4218 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 5120 7460 0 0 {name=l4219 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5280 7420 0 0 {name=l4220 sig_type=std_logic lab=CG_12}
C {devices/lab_pin.sym} 5280 7440 0 0 {name=l4221 sig_type=std_logic lab=CGB_12}
C {devices/lab_pin.sym} 5280 7460 0 0 {name=l4222 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} 5200 7640 0 0 {name=XPC_12}
C {devices/lab_pin.sym} 5120 7630 0 0 {name=l4223 sig_type=std_logic lab=BLG_II}
C {devices/lab_pin.sym} 5120 7650 0 0 {name=l4224 sig_type=std_logic lab=CG_12}
C {devices/lab_pin.sym} 5280 7630 0 0 {name=l4225 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5280 7650 0 0 {name=l4226 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} 5600 7440 0 0 {name=XLC_13}
C {devices/lab_pin.sym} 5520 7420 0 0 {name=l4227 sig_type=std_logic lab=CSEL_13}
C {devices/lab_pin.sym} 5520 7440 0 0 {name=l4228 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 5520 7460 0 0 {name=l4229 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 5680 7420 0 0 {name=l4230 sig_type=std_logic lab=CG_13}
C {devices/lab_pin.sym} 5680 7440 0 0 {name=l4231 sig_type=std_logic lab=CGB_13}
C {devices/lab_pin.sym} 5680 7460 0 0 {name=l4232 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} 5600 7640 0 0 {name=XPC_13}
C {devices/lab_pin.sym} 5520 7630 0 0 {name=l4233 sig_type=std_logic lab=BLG_II}
C {devices/lab_pin.sym} 5520 7650 0 0 {name=l4234 sig_type=std_logic lab=CG_13}
C {devices/lab_pin.sym} 5680 7630 0 0 {name=l4235 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5680 7650 0 0 {name=l4236 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} 6000 7440 0 0 {name=XLC_14}
C {devices/lab_pin.sym} 5920 7420 0 0 {name=l4237 sig_type=std_logic lab=CSEL_14}
C {devices/lab_pin.sym} 5920 7440 0 0 {name=l4238 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 5920 7460 0 0 {name=l4239 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6080 7420 0 0 {name=l4240 sig_type=std_logic lab=CG_14}
C {devices/lab_pin.sym} 6080 7440 0 0 {name=l4241 sig_type=std_logic lab=CGB_14}
C {devices/lab_pin.sym} 6080 7460 0 0 {name=l4242 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} 6000 7640 0 0 {name=XPC_14}
C {devices/lab_pin.sym} 5920 7630 0 0 {name=l4243 sig_type=std_logic lab=BLG_II}
C {devices/lab_pin.sym} 5920 7650 0 0 {name=l4244 sig_type=std_logic lab=CG_14}
C {devices/lab_pin.sym} 6080 7630 0 0 {name=l4245 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 6080 7650 0 0 {name=l4246 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} 6400 7440 0 0 {name=XLC_15}
C {devices/lab_pin.sym} 6320 7420 0 0 {name=l4247 sig_type=std_logic lab=CSEL_15}
C {devices/lab_pin.sym} 6320 7440 0 0 {name=l4248 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 6320 7460 0 0 {name=l4249 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6480 7420 0 0 {name=l4250 sig_type=std_logic lab=CG_15}
C {devices/lab_pin.sym} 6480 7440 0 0 {name=l4251 sig_type=std_logic lab=CGB_15}
C {devices/lab_pin.sym} 6480 7460 0 0 {name=l4252 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} 6400 7640 0 0 {name=XPC_15}
C {devices/lab_pin.sym} 6320 7630 0 0 {name=l4253 sig_type=std_logic lab=BLG_II}
C {devices/lab_pin.sym} 6320 7650 0 0 {name=l4254 sig_type=std_logic lab=CG_15}
C {devices/lab_pin.sym} 6480 7630 0 0 {name=l4255 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6480 7650 0 0 {name=l4256 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} 6800 7440 0 0 {name=XLC_16}
C {devices/lab_pin.sym} 6720 7420 0 0 {name=l4257 sig_type=std_logic lab=CSEL_16}
C {devices/lab_pin.sym} 6720 7440 0 0 {name=l4258 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 6720 7460 0 0 {name=l4259 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 6880 7420 0 0 {name=l4260 sig_type=std_logic lab=CG_16}
C {devices/lab_pin.sym} 6880 7440 0 0 {name=l4261 sig_type=std_logic lab=CGB_16}
C {devices/lab_pin.sym} 6880 7460 0 0 {name=l4262 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} 6800 7640 0 0 {name=XPC_16}
C {devices/lab_pin.sym} 6720 7630 0 0 {name=l4263 sig_type=std_logic lab=BLG_II}
C {devices/lab_pin.sym} 6720 7650 0 0 {name=l4264 sig_type=std_logic lab=CG_16}
C {devices/lab_pin.sym} 6880 7630 0 0 {name=l4265 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6880 7650 0 0 {name=l4266 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} 7200 7440 0 0 {name=XLC_17}
C {devices/lab_pin.sym} 7120 7420 0 0 {name=l4267 sig_type=std_logic lab=CSEL_17}
C {devices/lab_pin.sym} 7120 7440 0 0 {name=l4268 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 7120 7460 0 0 {name=l4269 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7280 7420 0 0 {name=l4270 sig_type=std_logic lab=CG_17}
C {devices/lab_pin.sym} 7280 7440 0 0 {name=l4271 sig_type=std_logic lab=CGB_17}
C {devices/lab_pin.sym} 7280 7460 0 0 {name=l4272 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} 7200 7640 0 0 {name=XPC_17}
C {devices/lab_pin.sym} 7120 7630 0 0 {name=l4273 sig_type=std_logic lab=BLG_II}
C {devices/lab_pin.sym} 7120 7650 0 0 {name=l4274 sig_type=std_logic lab=CG_17}
C {devices/lab_pin.sym} 7280 7630 0 0 {name=l4275 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7280 7650 0 0 {name=l4276 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} 7600 7440 0 0 {name=XLC_18}
C {devices/lab_pin.sym} 7520 7420 0 0 {name=l4277 sig_type=std_logic lab=CSEL_18}
C {devices/lab_pin.sym} 7520 7440 0 0 {name=l4278 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 7520 7460 0 0 {name=l4279 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 7680 7420 0 0 {name=l4280 sig_type=std_logic lab=CG_18}
C {devices/lab_pin.sym} 7680 7440 0 0 {name=l4281 sig_type=std_logic lab=CGB_18}
C {devices/lab_pin.sym} 7680 7460 0 0 {name=l4282 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} 7600 7640 0 0 {name=XPC_18}
C {devices/lab_pin.sym} 7520 7630 0 0 {name=l4283 sig_type=std_logic lab=BLG_II}
C {devices/lab_pin.sym} 7520 7650 0 0 {name=l4284 sig_type=std_logic lab=CG_18}
C {devices/lab_pin.sym} 7680 7630 0 0 {name=l4285 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7680 7650 0 0 {name=l4286 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} 8000 7440 0 0 {name=XLC_19}
C {devices/lab_pin.sym} 7920 7420 0 0 {name=l4287 sig_type=std_logic lab=CSEL_19}
C {devices/lab_pin.sym} 7920 7440 0 0 {name=l4288 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 7920 7460 0 0 {name=l4289 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8080 7420 0 0 {name=l4290 sig_type=std_logic lab=CG_19}
C {devices/lab_pin.sym} 8080 7440 0 0 {name=l4291 sig_type=std_logic lab=CGB_19}
C {devices/lab_pin.sym} 8080 7460 0 0 {name=l4292 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} 8000 7640 0 0 {name=XPC_19}
C {devices/lab_pin.sym} 7920 7630 0 0 {name=l4293 sig_type=std_logic lab=BLG_II}
C {devices/lab_pin.sym} 7920 7650 0 0 {name=l4294 sig_type=std_logic lab=CG_19}
C {devices/lab_pin.sym} 8080 7630 0 0 {name=l4295 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 8080 7650 0 0 {name=l4296 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} 8400 7440 0 0 {name=XLC_20}
C {devices/lab_pin.sym} 8320 7420 0 0 {name=l4297 sig_type=std_logic lab=CSEL_20}
C {devices/lab_pin.sym} 8320 7440 0 0 {name=l4298 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 8320 7460 0 0 {name=l4299 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8480 7420 0 0 {name=l4300 sig_type=std_logic lab=CG_20}
C {devices/lab_pin.sym} 8480 7440 0 0 {name=l4301 sig_type=std_logic lab=CGB_20}
C {devices/lab_pin.sym} 8480 7460 0 0 {name=l4302 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} 8400 7640 0 0 {name=XPC_20}
C {devices/lab_pin.sym} 8320 7630 0 0 {name=l4303 sig_type=std_logic lab=BLG_II}
C {devices/lab_pin.sym} 8320 7650 0 0 {name=l4304 sig_type=std_logic lab=CG_20}
C {devices/lab_pin.sym} 8480 7630 0 0 {name=l4305 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8480 7650 0 0 {name=l4306 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} 8800 7440 0 0 {name=XLC_21}
C {devices/lab_pin.sym} 8720 7420 0 0 {name=l4307 sig_type=std_logic lab=CSEL_21}
C {devices/lab_pin.sym} 8720 7440 0 0 {name=l4308 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 8720 7460 0 0 {name=l4309 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 8880 7420 0 0 {name=l4310 sig_type=std_logic lab=CG_21}
C {devices/lab_pin.sym} 8880 7440 0 0 {name=l4311 sig_type=std_logic lab=CGB_21}
C {devices/lab_pin.sym} 8880 7460 0 0 {name=l4312 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} 8800 7640 0 0 {name=XPC_21}
C {devices/lab_pin.sym} 8720 7630 0 0 {name=l4313 sig_type=std_logic lab=BLG_II}
C {devices/lab_pin.sym} 8720 7650 0 0 {name=l4314 sig_type=std_logic lab=CG_21}
C {devices/lab_pin.sym} 8880 7630 0 0 {name=l4315 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8880 7650 0 0 {name=l4316 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 9200 7440 0 0 {name=XLC_22}
C {devices/lab_pin.sym} 9120 7420 0 0 {name=l4317 sig_type=std_logic lab=CSEL_22}
C {devices/lab_pin.sym} 9120 7440 0 0 {name=l4318 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 9120 7460 0 0 {name=l4319 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 9280 7420 0 0 {name=l4320 sig_type=std_logic lab=CG_22}
C {devices/lab_pin.sym} 9280 7440 0 0 {name=l4321 sig_type=std_logic lab=CGB_22}
C {devices/lab_pin.sym} 9280 7460 0 0 {name=l4322 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} 9200 7640 0 0 {name=XPC_22}
C {devices/lab_pin.sym} 9120 7630 0 0 {name=l4323 sig_type=std_logic lab=BLG_III}
C {devices/lab_pin.sym} 9120 7650 0 0 {name=l4324 sig_type=std_logic lab=CG_22}
C {devices/lab_pin.sym} 9280 7630 0 0 {name=l4325 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9280 7650 0 0 {name=l4326 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 9600 7440 0 0 {name=XLC_23}
C {devices/lab_pin.sym} 9520 7420 0 0 {name=l4327 sig_type=std_logic lab=CSEL_23}
C {devices/lab_pin.sym} 9520 7440 0 0 {name=l4328 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 9520 7460 0 0 {name=l4329 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 9680 7420 0 0 {name=l4330 sig_type=std_logic lab=CG_23}
C {devices/lab_pin.sym} 9680 7440 0 0 {name=l4331 sig_type=std_logic lab=CGB_23}
C {devices/lab_pin.sym} 9680 7460 0 0 {name=l4332 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} 9600 7640 0 0 {name=XPC_23}
C {devices/lab_pin.sym} 9520 7630 0 0 {name=l4333 sig_type=std_logic lab=BLG_III}
C {devices/lab_pin.sym} 9520 7650 0 0 {name=l4334 sig_type=std_logic lab=CG_23}
C {devices/lab_pin.sym} 9680 7630 0 0 {name=l4335 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9680 7650 0 0 {name=l4336 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 10000 7440 0 0 {name=XLC_24}
C {devices/lab_pin.sym} 9920 7420 0 0 {name=l4337 sig_type=std_logic lab=CSEL_24}
C {devices/lab_pin.sym} 9920 7440 0 0 {name=l4338 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 9920 7460 0 0 {name=l4339 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 10080 7420 0 0 {name=l4340 sig_type=std_logic lab=CG_24}
C {devices/lab_pin.sym} 10080 7440 0 0 {name=l4341 sig_type=std_logic lab=CGB_24}
C {devices/lab_pin.sym} 10080 7460 0 0 {name=l4342 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} 10000 7640 0 0 {name=XPC_24}
C {devices/lab_pin.sym} 9920 7630 0 0 {name=l4343 sig_type=std_logic lab=BLG_III}
C {devices/lab_pin.sym} 9920 7650 0 0 {name=l4344 sig_type=std_logic lab=CG_24}
C {devices/lab_pin.sym} 10080 7630 0 0 {name=l4345 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 10080 7650 0 0 {name=l4346 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 10400 7440 0 0 {name=XLC_25}
C {devices/lab_pin.sym} 10320 7420 0 0 {name=l4347 sig_type=std_logic lab=CSEL_25}
C {devices/lab_pin.sym} 10320 7440 0 0 {name=l4348 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 10320 7460 0 0 {name=l4349 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 10480 7420 0 0 {name=l4350 sig_type=std_logic lab=CG_25}
C {devices/lab_pin.sym} 10480 7440 0 0 {name=l4351 sig_type=std_logic lab=CGB_25}
C {devices/lab_pin.sym} 10480 7460 0 0 {name=l4352 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} 10400 7640 0 0 {name=XPC_25}
C {devices/lab_pin.sym} 10320 7630 0 0 {name=l4353 sig_type=std_logic lab=BLG_III}
C {devices/lab_pin.sym} 10320 7650 0 0 {name=l4354 sig_type=std_logic lab=CG_25}
C {devices/lab_pin.sym} 10480 7630 0 0 {name=l4355 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10480 7650 0 0 {name=l4356 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 10800 7440 0 0 {name=XLC_26}
C {devices/lab_pin.sym} 10720 7420 0 0 {name=l4357 sig_type=std_logic lab=CSEL_26}
C {devices/lab_pin.sym} 10720 7440 0 0 {name=l4358 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 10720 7460 0 0 {name=l4359 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 10880 7420 0 0 {name=l4360 sig_type=std_logic lab=CG_26}
C {devices/lab_pin.sym} 10880 7440 0 0 {name=l4361 sig_type=std_logic lab=CGB_26}
C {devices/lab_pin.sym} 10880 7460 0 0 {name=l4362 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} 10800 7640 0 0 {name=XPC_26}
C {devices/lab_pin.sym} 10720 7630 0 0 {name=l4363 sig_type=std_logic lab=BLG_III}
C {devices/lab_pin.sym} 10720 7650 0 0 {name=l4364 sig_type=std_logic lab=CG_26}
C {devices/lab_pin.sym} 10880 7630 0 0 {name=l4365 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10880 7650 0 0 {name=l4366 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 11200 7440 0 0 {name=XLC_27}
C {devices/lab_pin.sym} 11120 7420 0 0 {name=l4367 sig_type=std_logic lab=CSEL_27}
C {devices/lab_pin.sym} 11120 7440 0 0 {name=l4368 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 11120 7460 0 0 {name=l4369 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 11280 7420 0 0 {name=l4370 sig_type=std_logic lab=CG_27}
C {devices/lab_pin.sym} 11280 7440 0 0 {name=l4371 sig_type=std_logic lab=CGB_27}
C {devices/lab_pin.sym} 11280 7460 0 0 {name=l4372 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} 11200 7640 0 0 {name=XPC_27}
C {devices/lab_pin.sym} 11120 7630 0 0 {name=l4373 sig_type=std_logic lab=BLG_III}
C {devices/lab_pin.sym} 11120 7650 0 0 {name=l4374 sig_type=std_logic lab=CG_27}
C {devices/lab_pin.sym} 11280 7630 0 0 {name=l4375 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11280 7650 0 0 {name=l4376 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 11600 7440 0 0 {name=XLC_28}
C {devices/lab_pin.sym} 11520 7420 0 0 {name=l4377 sig_type=std_logic lab=CSEL_28}
C {devices/lab_pin.sym} 11520 7440 0 0 {name=l4378 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 11520 7460 0 0 {name=l4379 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 11680 7420 0 0 {name=l4380 sig_type=std_logic lab=CG_28}
C {devices/lab_pin.sym} 11680 7440 0 0 {name=l4381 sig_type=std_logic lab=CGB_28}
C {devices/lab_pin.sym} 11680 7460 0 0 {name=l4382 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} 11600 7640 0 0 {name=XPC_28}
C {devices/lab_pin.sym} 11520 7630 0 0 {name=l4383 sig_type=std_logic lab=BLG_III}
C {devices/lab_pin.sym} 11520 7650 0 0 {name=l4384 sig_type=std_logic lab=CG_28}
C {devices/lab_pin.sym} 11680 7630 0 0 {name=l4385 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11680 7650 0 0 {name=l4386 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 12000 7440 0 0 {name=XLC_29}
C {devices/lab_pin.sym} 11920 7420 0 0 {name=l4387 sig_type=std_logic lab=CSEL_29}
C {devices/lab_pin.sym} 11920 7440 0 0 {name=l4388 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 11920 7460 0 0 {name=l4389 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 12080 7420 0 0 {name=l4390 sig_type=std_logic lab=CG_29}
C {devices/lab_pin.sym} 12080 7440 0 0 {name=l4391 sig_type=std_logic lab=CGB_29}
C {devices/lab_pin.sym} 12080 7460 0 0 {name=l4392 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} 12000 7640 0 0 {name=XPC_29}
C {devices/lab_pin.sym} 11920 7630 0 0 {name=l4393 sig_type=std_logic lab=BLG_III}
C {devices/lab_pin.sym} 11920 7650 0 0 {name=l4394 sig_type=std_logic lab=CG_29}
C {devices/lab_pin.sym} 12080 7630 0 0 {name=l4395 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 12080 7650 0 0 {name=l4396 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 12400 7440 0 0 {name=XLC_30}
C {devices/lab_pin.sym} 12320 7420 0 0 {name=l4397 sig_type=std_logic lab=CSEL_30}
C {devices/lab_pin.sym} 12320 7440 0 0 {name=l4398 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 12320 7460 0 0 {name=l4399 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 12480 7420 0 0 {name=l4400 sig_type=std_logic lab=CG_30}
C {devices/lab_pin.sym} 12480 7440 0 0 {name=l4401 sig_type=std_logic lab=CGB_30}
C {devices/lab_pin.sym} 12480 7460 0 0 {name=l4402 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} 12400 7640 0 0 {name=XPC_30}
C {devices/lab_pin.sym} 12320 7630 0 0 {name=l4403 sig_type=std_logic lab=BLG_III}
C {devices/lab_pin.sym} 12320 7650 0 0 {name=l4404 sig_type=std_logic lab=CG_30}
C {devices/lab_pin.sym} 12480 7630 0 0 {name=l4405 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12480 7650 0 0 {name=l4406 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 12800 7440 0 0 {name=XLC_31}
C {devices/lab_pin.sym} 12720 7420 0 0 {name=l4407 sig_type=std_logic lab=CSEL_31}
C {devices/lab_pin.sym} 12720 7440 0 0 {name=l4408 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 12720 7460 0 0 {name=l4409 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 12880 7420 0 0 {name=l4410 sig_type=std_logic lab=CG_31}
C {devices/lab_pin.sym} 12880 7440 0 0 {name=l4411 sig_type=std_logic lab=CGB_31}
C {devices/lab_pin.sym} 12880 7460 0 0 {name=l4412 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} 12800 7640 0 0 {name=XPC_31}
C {devices/lab_pin.sym} 12720 7630 0 0 {name=l4413 sig_type=std_logic lab=BLG_III}
C {devices/lab_pin.sym} 12720 7650 0 0 {name=l4414 sig_type=std_logic lab=CG_31}
C {devices/lab_pin.sym} 12880 7630 0 0 {name=l4415 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12880 7650 0 0 {name=l4416 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 300 0 0 {name=XLR_0_I}
C {devices/lab_pin.sym} -380 280 0 0 {name=l4417 sig_type=std_logic lab=RSEL_0}
C {devices/lab_pin.sym} -380 300 0 0 {name=l4418 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 320 0 0 {name=l4419 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 280 0 0 {name=l4420 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} -220 300 0 0 {name=l4421 sig_type=std_logic lab=RGB_0_I}
C {devices/lab_pin.sym} -220 320 0 0 {name=l4422 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 300 0 0 {name=XPR_0_I}
C {devices/lab_pin.sym} -80 290 0 0 {name=l4423 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} -80 310 0 0 {name=l4424 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 80 290 0 0 {name=l4425 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 310 0 0 {name=l4426 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 520 0 0 {name=XLR_1_I}
C {devices/lab_pin.sym} -380 500 0 0 {name=l4427 sig_type=std_logic lab=RSEL_1}
C {devices/lab_pin.sym} -380 520 0 0 {name=l4428 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 540 0 0 {name=l4429 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 500 0 0 {name=l4430 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} -220 520 0 0 {name=l4431 sig_type=std_logic lab=RGB_1_I}
C {devices/lab_pin.sym} -220 540 0 0 {name=l4432 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 520 0 0 {name=XPR_1_I}
C {devices/lab_pin.sym} -80 510 0 0 {name=l4433 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} -80 530 0 0 {name=l4434 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 80 510 0 0 {name=l4435 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 530 0 0 {name=l4436 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 740 0 0 {name=XLR_2_I}
C {devices/lab_pin.sym} -380 720 0 0 {name=l4437 sig_type=std_logic lab=RSEL_2}
C {devices/lab_pin.sym} -380 740 0 0 {name=l4438 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 760 0 0 {name=l4439 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 720 0 0 {name=l4440 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} -220 740 0 0 {name=l4441 sig_type=std_logic lab=RGB_2_I}
C {devices/lab_pin.sym} -220 760 0 0 {name=l4442 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 740 0 0 {name=XPR_2_I}
C {devices/lab_pin.sym} -80 730 0 0 {name=l4443 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} -80 750 0 0 {name=l4444 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 80 730 0 0 {name=l4445 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 750 0 0 {name=l4446 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 960 0 0 {name=XLR_3_I}
C {devices/lab_pin.sym} -380 940 0 0 {name=l4447 sig_type=std_logic lab=RSEL_3}
C {devices/lab_pin.sym} -380 960 0 0 {name=l4448 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 980 0 0 {name=l4449 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 940 0 0 {name=l4450 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} -220 960 0 0 {name=l4451 sig_type=std_logic lab=RGB_3_I}
C {devices/lab_pin.sym} -220 980 0 0 {name=l4452 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 960 0 0 {name=XPR_3_I}
C {devices/lab_pin.sym} -80 950 0 0 {name=l4453 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} -80 970 0 0 {name=l4454 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 80 950 0 0 {name=l4455 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 970 0 0 {name=l4456 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 1180 0 0 {name=XLR_4_I}
C {devices/lab_pin.sym} -380 1160 0 0 {name=l4457 sig_type=std_logic lab=RSEL_4}
C {devices/lab_pin.sym} -380 1180 0 0 {name=l4458 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 1200 0 0 {name=l4459 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 1160 0 0 {name=l4460 sig_type=std_logic lab=WL_4_I}
C {devices/lab_pin.sym} -220 1180 0 0 {name=l4461 sig_type=std_logic lab=RGB_4_I}
C {devices/lab_pin.sym} -220 1200 0 0 {name=l4462 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 1180 0 0 {name=XPR_4_I}
C {devices/lab_pin.sym} -80 1170 0 0 {name=l4463 sig_type=std_logic lab=PL_4_I}
C {devices/lab_pin.sym} -80 1190 0 0 {name=l4464 sig_type=std_logic lab=WL_4_I}
C {devices/lab_pin.sym} 80 1170 0 0 {name=l4465 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 1190 0 0 {name=l4466 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 1400 0 0 {name=XLR_5_I}
C {devices/lab_pin.sym} -380 1380 0 0 {name=l4467 sig_type=std_logic lab=RSEL_5}
C {devices/lab_pin.sym} -380 1400 0 0 {name=l4468 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 1420 0 0 {name=l4469 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 1380 0 0 {name=l4470 sig_type=std_logic lab=WL_5_I}
C {devices/lab_pin.sym} -220 1400 0 0 {name=l4471 sig_type=std_logic lab=RGB_5_I}
C {devices/lab_pin.sym} -220 1420 0 0 {name=l4472 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 1400 0 0 {name=XPR_5_I}
C {devices/lab_pin.sym} -80 1390 0 0 {name=l4473 sig_type=std_logic lab=PL_5_I}
C {devices/lab_pin.sym} -80 1410 0 0 {name=l4474 sig_type=std_logic lab=WL_5_I}
C {devices/lab_pin.sym} 80 1390 0 0 {name=l4475 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 1410 0 0 {name=l4476 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 1620 0 0 {name=XLR_6_I}
C {devices/lab_pin.sym} -380 1600 0 0 {name=l4477 sig_type=std_logic lab=RSEL_6}
C {devices/lab_pin.sym} -380 1620 0 0 {name=l4478 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 1640 0 0 {name=l4479 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 1600 0 0 {name=l4480 sig_type=std_logic lab=WL_6_I}
C {devices/lab_pin.sym} -220 1620 0 0 {name=l4481 sig_type=std_logic lab=RGB_6_I}
C {devices/lab_pin.sym} -220 1640 0 0 {name=l4482 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 1620 0 0 {name=XPR_6_I}
C {devices/lab_pin.sym} -80 1610 0 0 {name=l4483 sig_type=std_logic lab=PL_6_I}
C {devices/lab_pin.sym} -80 1630 0 0 {name=l4484 sig_type=std_logic lab=WL_6_I}
C {devices/lab_pin.sym} 80 1610 0 0 {name=l4485 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 1630 0 0 {name=l4486 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 1840 0 0 {name=XLR_7_I}
C {devices/lab_pin.sym} -380 1820 0 0 {name=l4487 sig_type=std_logic lab=RSEL_7}
C {devices/lab_pin.sym} -380 1840 0 0 {name=l4488 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 1860 0 0 {name=l4489 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 1820 0 0 {name=l4490 sig_type=std_logic lab=WL_7_I}
C {devices/lab_pin.sym} -220 1840 0 0 {name=l4491 sig_type=std_logic lab=RGB_7_I}
C {devices/lab_pin.sym} -220 1860 0 0 {name=l4492 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 1840 0 0 {name=XPR_7_I}
C {devices/lab_pin.sym} -80 1830 0 0 {name=l4493 sig_type=std_logic lab=PL_7_I}
C {devices/lab_pin.sym} -80 1850 0 0 {name=l4494 sig_type=std_logic lab=WL_7_I}
C {devices/lab_pin.sym} 80 1830 0 0 {name=l4495 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 1850 0 0 {name=l4496 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 2060 0 0 {name=XLR_8_I}
C {devices/lab_pin.sym} -380 2040 0 0 {name=l4497 sig_type=std_logic lab=RSEL_8}
C {devices/lab_pin.sym} -380 2060 0 0 {name=l4498 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 2080 0 0 {name=l4499 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 2040 0 0 {name=l4500 sig_type=std_logic lab=WL_8_I}
C {devices/lab_pin.sym} -220 2060 0 0 {name=l4501 sig_type=std_logic lab=RGB_8_I}
C {devices/lab_pin.sym} -220 2080 0 0 {name=l4502 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 2060 0 0 {name=XPR_8_I}
C {devices/lab_pin.sym} -80 2050 0 0 {name=l4503 sig_type=std_logic lab=PL_8_I}
C {devices/lab_pin.sym} -80 2070 0 0 {name=l4504 sig_type=std_logic lab=WL_8_I}
C {devices/lab_pin.sym} 80 2050 0 0 {name=l4505 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 2070 0 0 {name=l4506 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 2280 0 0 {name=XLR_9_I}
C {devices/lab_pin.sym} -380 2260 0 0 {name=l4507 sig_type=std_logic lab=RSEL_9}
C {devices/lab_pin.sym} -380 2280 0 0 {name=l4508 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 2300 0 0 {name=l4509 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 2260 0 0 {name=l4510 sig_type=std_logic lab=WL_9_I}
C {devices/lab_pin.sym} -220 2280 0 0 {name=l4511 sig_type=std_logic lab=RGB_9_I}
C {devices/lab_pin.sym} -220 2300 0 0 {name=l4512 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 2280 0 0 {name=XPR_9_I}
C {devices/lab_pin.sym} -80 2270 0 0 {name=l4513 sig_type=std_logic lab=PL_9_I}
C {devices/lab_pin.sym} -80 2290 0 0 {name=l4514 sig_type=std_logic lab=WL_9_I}
C {devices/lab_pin.sym} 80 2270 0 0 {name=l4515 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 2290 0 0 {name=l4516 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 2500 0 0 {name=XLR_10_I}
C {devices/lab_pin.sym} -380 2480 0 0 {name=l4517 sig_type=std_logic lab=RSEL_10}
C {devices/lab_pin.sym} -380 2500 0 0 {name=l4518 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 2520 0 0 {name=l4519 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 2480 0 0 {name=l4520 sig_type=std_logic lab=WL_10_I}
C {devices/lab_pin.sym} -220 2500 0 0 {name=l4521 sig_type=std_logic lab=RGB_10_I}
C {devices/lab_pin.sym} -220 2520 0 0 {name=l4522 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 2500 0 0 {name=XPR_10_I}
C {devices/lab_pin.sym} -80 2490 0 0 {name=l4523 sig_type=std_logic lab=PL_10_I}
C {devices/lab_pin.sym} -80 2510 0 0 {name=l4524 sig_type=std_logic lab=WL_10_I}
C {devices/lab_pin.sym} 80 2490 0 0 {name=l4525 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 2510 0 0 {name=l4526 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 2720 0 0 {name=XLR_11_I}
C {devices/lab_pin.sym} -380 2700 0 0 {name=l4527 sig_type=std_logic lab=RSEL_11}
C {devices/lab_pin.sym} -380 2720 0 0 {name=l4528 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 2740 0 0 {name=l4529 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 2700 0 0 {name=l4530 sig_type=std_logic lab=WL_11_I}
C {devices/lab_pin.sym} -220 2720 0 0 {name=l4531 sig_type=std_logic lab=RGB_11_I}
C {devices/lab_pin.sym} -220 2740 0 0 {name=l4532 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 2720 0 0 {name=XPR_11_I}
C {devices/lab_pin.sym} -80 2710 0 0 {name=l4533 sig_type=std_logic lab=PL_11_I}
C {devices/lab_pin.sym} -80 2730 0 0 {name=l4534 sig_type=std_logic lab=WL_11_I}
C {devices/lab_pin.sym} 80 2710 0 0 {name=l4535 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 2730 0 0 {name=l4536 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 2940 0 0 {name=XLR_12_I}
C {devices/lab_pin.sym} -380 2920 0 0 {name=l4537 sig_type=std_logic lab=RSEL_12}
C {devices/lab_pin.sym} -380 2940 0 0 {name=l4538 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 2960 0 0 {name=l4539 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 2920 0 0 {name=l4540 sig_type=std_logic lab=WL_12_I}
C {devices/lab_pin.sym} -220 2940 0 0 {name=l4541 sig_type=std_logic lab=RGB_12_I}
C {devices/lab_pin.sym} -220 2960 0 0 {name=l4542 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 2940 0 0 {name=XPR_12_I}
C {devices/lab_pin.sym} -80 2930 0 0 {name=l4543 sig_type=std_logic lab=PL_12_I}
C {devices/lab_pin.sym} -80 2950 0 0 {name=l4544 sig_type=std_logic lab=WL_12_I}
C {devices/lab_pin.sym} 80 2930 0 0 {name=l4545 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 2950 0 0 {name=l4546 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 3160 0 0 {name=XLR_13_I}
C {devices/lab_pin.sym} -380 3140 0 0 {name=l4547 sig_type=std_logic lab=RSEL_13}
C {devices/lab_pin.sym} -380 3160 0 0 {name=l4548 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 3180 0 0 {name=l4549 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 3140 0 0 {name=l4550 sig_type=std_logic lab=WL_13_I}
C {devices/lab_pin.sym} -220 3160 0 0 {name=l4551 sig_type=std_logic lab=RGB_13_I}
C {devices/lab_pin.sym} -220 3180 0 0 {name=l4552 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 3160 0 0 {name=XPR_13_I}
C {devices/lab_pin.sym} -80 3150 0 0 {name=l4553 sig_type=std_logic lab=PL_13_I}
C {devices/lab_pin.sym} -80 3170 0 0 {name=l4554 sig_type=std_logic lab=WL_13_I}
C {devices/lab_pin.sym} 80 3150 0 0 {name=l4555 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 3170 0 0 {name=l4556 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 3380 0 0 {name=XLR_14_I}
C {devices/lab_pin.sym} -380 3360 0 0 {name=l4557 sig_type=std_logic lab=RSEL_14}
C {devices/lab_pin.sym} -380 3380 0 0 {name=l4558 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 3400 0 0 {name=l4559 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 3360 0 0 {name=l4560 sig_type=std_logic lab=WL_14_I}
C {devices/lab_pin.sym} -220 3380 0 0 {name=l4561 sig_type=std_logic lab=RGB_14_I}
C {devices/lab_pin.sym} -220 3400 0 0 {name=l4562 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 3380 0 0 {name=XPR_14_I}
C {devices/lab_pin.sym} -80 3370 0 0 {name=l4563 sig_type=std_logic lab=PL_14_I}
C {devices/lab_pin.sym} -80 3390 0 0 {name=l4564 sig_type=std_logic lab=WL_14_I}
C {devices/lab_pin.sym} 80 3370 0 0 {name=l4565 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 3390 0 0 {name=l4566 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 3600 0 0 {name=XLR_15_I}
C {devices/lab_pin.sym} -380 3580 0 0 {name=l4567 sig_type=std_logic lab=RSEL_15}
C {devices/lab_pin.sym} -380 3600 0 0 {name=l4568 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 3620 0 0 {name=l4569 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 3580 0 0 {name=l4570 sig_type=std_logic lab=WL_15_I}
C {devices/lab_pin.sym} -220 3600 0 0 {name=l4571 sig_type=std_logic lab=RGB_15_I}
C {devices/lab_pin.sym} -220 3620 0 0 {name=l4572 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 3600 0 0 {name=XPR_15_I}
C {devices/lab_pin.sym} -80 3590 0 0 {name=l4573 sig_type=std_logic lab=PL_15_I}
C {devices/lab_pin.sym} -80 3610 0 0 {name=l4574 sig_type=std_logic lab=WL_15_I}
C {devices/lab_pin.sym} 80 3590 0 0 {name=l4575 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 3610 0 0 {name=l4576 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 3820 0 0 {name=XLR_16_I}
C {devices/lab_pin.sym} -380 3800 0 0 {name=l4577 sig_type=std_logic lab=RSEL_16}
C {devices/lab_pin.sym} -380 3820 0 0 {name=l4578 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 3840 0 0 {name=l4579 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 3800 0 0 {name=l4580 sig_type=std_logic lab=WL_16_I}
C {devices/lab_pin.sym} -220 3820 0 0 {name=l4581 sig_type=std_logic lab=RGB_16_I}
C {devices/lab_pin.sym} -220 3840 0 0 {name=l4582 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 3820 0 0 {name=XPR_16_I}
C {devices/lab_pin.sym} -80 3810 0 0 {name=l4583 sig_type=std_logic lab=PL_16_I}
C {devices/lab_pin.sym} -80 3830 0 0 {name=l4584 sig_type=std_logic lab=WL_16_I}
C {devices/lab_pin.sym} 80 3810 0 0 {name=l4585 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 3830 0 0 {name=l4586 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 4040 0 0 {name=XLR_17_I}
C {devices/lab_pin.sym} -380 4020 0 0 {name=l4587 sig_type=std_logic lab=RSEL_17}
C {devices/lab_pin.sym} -380 4040 0 0 {name=l4588 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 4060 0 0 {name=l4589 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 4020 0 0 {name=l4590 sig_type=std_logic lab=WL_17_I}
C {devices/lab_pin.sym} -220 4040 0 0 {name=l4591 sig_type=std_logic lab=RGB_17_I}
C {devices/lab_pin.sym} -220 4060 0 0 {name=l4592 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 4040 0 0 {name=XPR_17_I}
C {devices/lab_pin.sym} -80 4030 0 0 {name=l4593 sig_type=std_logic lab=PL_17_I}
C {devices/lab_pin.sym} -80 4050 0 0 {name=l4594 sig_type=std_logic lab=WL_17_I}
C {devices/lab_pin.sym} 80 4030 0 0 {name=l4595 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 4050 0 0 {name=l4596 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 4260 0 0 {name=XLR_18_I}
C {devices/lab_pin.sym} -380 4240 0 0 {name=l4597 sig_type=std_logic lab=RSEL_18}
C {devices/lab_pin.sym} -380 4260 0 0 {name=l4598 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 4280 0 0 {name=l4599 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 4240 0 0 {name=l4600 sig_type=std_logic lab=WL_18_I}
C {devices/lab_pin.sym} -220 4260 0 0 {name=l4601 sig_type=std_logic lab=RGB_18_I}
C {devices/lab_pin.sym} -220 4280 0 0 {name=l4602 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 4260 0 0 {name=XPR_18_I}
C {devices/lab_pin.sym} -80 4250 0 0 {name=l4603 sig_type=std_logic lab=PL_18_I}
C {devices/lab_pin.sym} -80 4270 0 0 {name=l4604 sig_type=std_logic lab=WL_18_I}
C {devices/lab_pin.sym} 80 4250 0 0 {name=l4605 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 4270 0 0 {name=l4606 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 4480 0 0 {name=XLR_19_I}
C {devices/lab_pin.sym} -380 4460 0 0 {name=l4607 sig_type=std_logic lab=RSEL_19}
C {devices/lab_pin.sym} -380 4480 0 0 {name=l4608 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 4500 0 0 {name=l4609 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 4460 0 0 {name=l4610 sig_type=std_logic lab=WL_19_I}
C {devices/lab_pin.sym} -220 4480 0 0 {name=l4611 sig_type=std_logic lab=RGB_19_I}
C {devices/lab_pin.sym} -220 4500 0 0 {name=l4612 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 4480 0 0 {name=XPR_19_I}
C {devices/lab_pin.sym} -80 4470 0 0 {name=l4613 sig_type=std_logic lab=PL_19_I}
C {devices/lab_pin.sym} -80 4490 0 0 {name=l4614 sig_type=std_logic lab=WL_19_I}
C {devices/lab_pin.sym} 80 4470 0 0 {name=l4615 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 4490 0 0 {name=l4616 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 4700 0 0 {name=XLR_20_I}
C {devices/lab_pin.sym} -380 4680 0 0 {name=l4617 sig_type=std_logic lab=RSEL_20}
C {devices/lab_pin.sym} -380 4700 0 0 {name=l4618 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 4720 0 0 {name=l4619 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 4680 0 0 {name=l4620 sig_type=std_logic lab=WL_20_I}
C {devices/lab_pin.sym} -220 4700 0 0 {name=l4621 sig_type=std_logic lab=RGB_20_I}
C {devices/lab_pin.sym} -220 4720 0 0 {name=l4622 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 4700 0 0 {name=XPR_20_I}
C {devices/lab_pin.sym} -80 4690 0 0 {name=l4623 sig_type=std_logic lab=PL_20_I}
C {devices/lab_pin.sym} -80 4710 0 0 {name=l4624 sig_type=std_logic lab=WL_20_I}
C {devices/lab_pin.sym} 80 4690 0 0 {name=l4625 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 4710 0 0 {name=l4626 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 4920 0 0 {name=XLR_21_I}
C {devices/lab_pin.sym} -380 4900 0 0 {name=l4627 sig_type=std_logic lab=RSEL_21}
C {devices/lab_pin.sym} -380 4920 0 0 {name=l4628 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 4940 0 0 {name=l4629 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 4900 0 0 {name=l4630 sig_type=std_logic lab=WL_21_I}
C {devices/lab_pin.sym} -220 4920 0 0 {name=l4631 sig_type=std_logic lab=RGB_21_I}
C {devices/lab_pin.sym} -220 4940 0 0 {name=l4632 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 4920 0 0 {name=XPR_21_I}
C {devices/lab_pin.sym} -80 4910 0 0 {name=l4633 sig_type=std_logic lab=PL_21_I}
C {devices/lab_pin.sym} -80 4930 0 0 {name=l4634 sig_type=std_logic lab=WL_21_I}
C {devices/lab_pin.sym} 80 4910 0 0 {name=l4635 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 4930 0 0 {name=l4636 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 5140 0 0 {name=XLR_22_I}
C {devices/lab_pin.sym} -380 5120 0 0 {name=l4637 sig_type=std_logic lab=RSEL_22}
C {devices/lab_pin.sym} -380 5140 0 0 {name=l4638 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 5160 0 0 {name=l4639 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 5120 0 0 {name=l4640 sig_type=std_logic lab=WL_22_I}
C {devices/lab_pin.sym} -220 5140 0 0 {name=l4641 sig_type=std_logic lab=RGB_22_I}
C {devices/lab_pin.sym} -220 5160 0 0 {name=l4642 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 5140 0 0 {name=XPR_22_I}
C {devices/lab_pin.sym} -80 5130 0 0 {name=l4643 sig_type=std_logic lab=PL_22_I}
C {devices/lab_pin.sym} -80 5150 0 0 {name=l4644 sig_type=std_logic lab=WL_22_I}
C {devices/lab_pin.sym} 80 5130 0 0 {name=l4645 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 5150 0 0 {name=l4646 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 5360 0 0 {name=XLR_23_I}
C {devices/lab_pin.sym} -380 5340 0 0 {name=l4647 sig_type=std_logic lab=RSEL_23}
C {devices/lab_pin.sym} -380 5360 0 0 {name=l4648 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 5380 0 0 {name=l4649 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 5340 0 0 {name=l4650 sig_type=std_logic lab=WL_23_I}
C {devices/lab_pin.sym} -220 5360 0 0 {name=l4651 sig_type=std_logic lab=RGB_23_I}
C {devices/lab_pin.sym} -220 5380 0 0 {name=l4652 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 5360 0 0 {name=XPR_23_I}
C {devices/lab_pin.sym} -80 5350 0 0 {name=l4653 sig_type=std_logic lab=PL_23_I}
C {devices/lab_pin.sym} -80 5370 0 0 {name=l4654 sig_type=std_logic lab=WL_23_I}
C {devices/lab_pin.sym} 80 5350 0 0 {name=l4655 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 5370 0 0 {name=l4656 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 5580 0 0 {name=XLR_24_I}
C {devices/lab_pin.sym} -380 5560 0 0 {name=l4657 sig_type=std_logic lab=RSEL_24}
C {devices/lab_pin.sym} -380 5580 0 0 {name=l4658 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 5600 0 0 {name=l4659 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 5560 0 0 {name=l4660 sig_type=std_logic lab=WL_24_I}
C {devices/lab_pin.sym} -220 5580 0 0 {name=l4661 sig_type=std_logic lab=RGB_24_I}
C {devices/lab_pin.sym} -220 5600 0 0 {name=l4662 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 5580 0 0 {name=XPR_24_I}
C {devices/lab_pin.sym} -80 5570 0 0 {name=l4663 sig_type=std_logic lab=PL_24_I}
C {devices/lab_pin.sym} -80 5590 0 0 {name=l4664 sig_type=std_logic lab=WL_24_I}
C {devices/lab_pin.sym} 80 5570 0 0 {name=l4665 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 5590 0 0 {name=l4666 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 5800 0 0 {name=XLR_25_I}
C {devices/lab_pin.sym} -380 5780 0 0 {name=l4667 sig_type=std_logic lab=RSEL_25}
C {devices/lab_pin.sym} -380 5800 0 0 {name=l4668 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 5820 0 0 {name=l4669 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 5780 0 0 {name=l4670 sig_type=std_logic lab=WL_25_I}
C {devices/lab_pin.sym} -220 5800 0 0 {name=l4671 sig_type=std_logic lab=RGB_25_I}
C {devices/lab_pin.sym} -220 5820 0 0 {name=l4672 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 5800 0 0 {name=XPR_25_I}
C {devices/lab_pin.sym} -80 5790 0 0 {name=l4673 sig_type=std_logic lab=PL_25_I}
C {devices/lab_pin.sym} -80 5810 0 0 {name=l4674 sig_type=std_logic lab=WL_25_I}
C {devices/lab_pin.sym} 80 5790 0 0 {name=l4675 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 5810 0 0 {name=l4676 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 6020 0 0 {name=XLR_26_I}
C {devices/lab_pin.sym} -380 6000 0 0 {name=l4677 sig_type=std_logic lab=RSEL_26}
C {devices/lab_pin.sym} -380 6020 0 0 {name=l4678 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 6040 0 0 {name=l4679 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 6000 0 0 {name=l4680 sig_type=std_logic lab=WL_26_I}
C {devices/lab_pin.sym} -220 6020 0 0 {name=l4681 sig_type=std_logic lab=RGB_26_I}
C {devices/lab_pin.sym} -220 6040 0 0 {name=l4682 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 6020 0 0 {name=XPR_26_I}
C {devices/lab_pin.sym} -80 6010 0 0 {name=l4683 sig_type=std_logic lab=PL_26_I}
C {devices/lab_pin.sym} -80 6030 0 0 {name=l4684 sig_type=std_logic lab=WL_26_I}
C {devices/lab_pin.sym} 80 6010 0 0 {name=l4685 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 6030 0 0 {name=l4686 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 6240 0 0 {name=XLR_27_I}
C {devices/lab_pin.sym} -380 6220 0 0 {name=l4687 sig_type=std_logic lab=RSEL_27}
C {devices/lab_pin.sym} -380 6240 0 0 {name=l4688 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 6260 0 0 {name=l4689 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 6220 0 0 {name=l4690 sig_type=std_logic lab=WL_27_I}
C {devices/lab_pin.sym} -220 6240 0 0 {name=l4691 sig_type=std_logic lab=RGB_27_I}
C {devices/lab_pin.sym} -220 6260 0 0 {name=l4692 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 6240 0 0 {name=XPR_27_I}
C {devices/lab_pin.sym} -80 6230 0 0 {name=l4693 sig_type=std_logic lab=PL_27_I}
C {devices/lab_pin.sym} -80 6250 0 0 {name=l4694 sig_type=std_logic lab=WL_27_I}
C {devices/lab_pin.sym} 80 6230 0 0 {name=l4695 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 6250 0 0 {name=l4696 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 6460 0 0 {name=XLR_28_I}
C {devices/lab_pin.sym} -380 6440 0 0 {name=l4697 sig_type=std_logic lab=RSEL_28}
C {devices/lab_pin.sym} -380 6460 0 0 {name=l4698 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 6480 0 0 {name=l4699 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 6440 0 0 {name=l4700 sig_type=std_logic lab=WL_28_I}
C {devices/lab_pin.sym} -220 6460 0 0 {name=l4701 sig_type=std_logic lab=RGB_28_I}
C {devices/lab_pin.sym} -220 6480 0 0 {name=l4702 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 6460 0 0 {name=XPR_28_I}
C {devices/lab_pin.sym} -80 6450 0 0 {name=l4703 sig_type=std_logic lab=PL_28_I}
C {devices/lab_pin.sym} -80 6470 0 0 {name=l4704 sig_type=std_logic lab=WL_28_I}
C {devices/lab_pin.sym} 80 6450 0 0 {name=l4705 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 6470 0 0 {name=l4706 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 6680 0 0 {name=XLR_29_I}
C {devices/lab_pin.sym} -380 6660 0 0 {name=l4707 sig_type=std_logic lab=RSEL_29}
C {devices/lab_pin.sym} -380 6680 0 0 {name=l4708 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 6700 0 0 {name=l4709 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 6660 0 0 {name=l4710 sig_type=std_logic lab=WL_29_I}
C {devices/lab_pin.sym} -220 6680 0 0 {name=l4711 sig_type=std_logic lab=RGB_29_I}
C {devices/lab_pin.sym} -220 6700 0 0 {name=l4712 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 6680 0 0 {name=XPR_29_I}
C {devices/lab_pin.sym} -80 6670 0 0 {name=l4713 sig_type=std_logic lab=PL_29_I}
C {devices/lab_pin.sym} -80 6690 0 0 {name=l4714 sig_type=std_logic lab=WL_29_I}
C {devices/lab_pin.sym} 80 6670 0 0 {name=l4715 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 6690 0 0 {name=l4716 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 6900 0 0 {name=XLR_30_I}
C {devices/lab_pin.sym} -380 6880 0 0 {name=l4717 sig_type=std_logic lab=RSEL_30}
C {devices/lab_pin.sym} -380 6900 0 0 {name=l4718 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 6920 0 0 {name=l4719 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 6880 0 0 {name=l4720 sig_type=std_logic lab=WL_30_I}
C {devices/lab_pin.sym} -220 6900 0 0 {name=l4721 sig_type=std_logic lab=RGB_30_I}
C {devices/lab_pin.sym} -220 6920 0 0 {name=l4722 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 6900 0 0 {name=XPR_30_I}
C {devices/lab_pin.sym} -80 6890 0 0 {name=l4723 sig_type=std_logic lab=PL_30_I}
C {devices/lab_pin.sym} -80 6910 0 0 {name=l4724 sig_type=std_logic lab=WL_30_I}
C {devices/lab_pin.sym} 80 6890 0 0 {name=l4725 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 6910 0 0 {name=l4726 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 7120 0 0 {name=XLR_31_I}
C {devices/lab_pin.sym} -380 7100 0 0 {name=l4727 sig_type=std_logic lab=RSEL_31}
C {devices/lab_pin.sym} -380 7120 0 0 {name=l4728 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 7140 0 0 {name=l4729 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 7100 0 0 {name=l4730 sig_type=std_logic lab=WL_31_I}
C {devices/lab_pin.sym} -220 7120 0 0 {name=l4731 sig_type=std_logic lab=RGB_31_I}
C {devices/lab_pin.sym} -220 7140 0 0 {name=l4732 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 7120 0 0 {name=XPR_31_I}
C {devices/lab_pin.sym} -80 7110 0 0 {name=l4733 sig_type=std_logic lab=PL_31_I}
C {devices/lab_pin.sym} -80 7130 0 0 {name=l4734 sig_type=std_logic lab=WL_31_I}
C {devices/lab_pin.sym} 80 7110 0 0 {name=l4735 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 7130 0 0 {name=l4736 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 300 0 0 {name=XLR_0_II}
C {devices/lab_pin.sym} -1080 280 0 0 {name=l4737 sig_type=std_logic lab=RSEL_0}
C {devices/lab_pin.sym} -1080 300 0 0 {name=l4738 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 320 0 0 {name=l4739 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 280 0 0 {name=l4740 sig_type=std_logic lab=WL_0_II}
C {devices/lab_pin.sym} -920 300 0 0 {name=l4741 sig_type=std_logic lab=RGB_0_II}
C {devices/lab_pin.sym} -920 320 0 0 {name=l4742 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 300 0 0 {name=XPR_0_II}
C {devices/lab_pin.sym} -780 290 0 0 {name=l4743 sig_type=std_logic lab=PL_0_II}
C {devices/lab_pin.sym} -780 310 0 0 {name=l4744 sig_type=std_logic lab=WL_0_II}
C {devices/lab_pin.sym} -620 290 0 0 {name=l4745 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 310 0 0 {name=l4746 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 520 0 0 {name=XLR_1_II}
C {devices/lab_pin.sym} -1080 500 0 0 {name=l4747 sig_type=std_logic lab=RSEL_1}
C {devices/lab_pin.sym} -1080 520 0 0 {name=l4748 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 540 0 0 {name=l4749 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 500 0 0 {name=l4750 sig_type=std_logic lab=WL_1_II}
C {devices/lab_pin.sym} -920 520 0 0 {name=l4751 sig_type=std_logic lab=RGB_1_II}
C {devices/lab_pin.sym} -920 540 0 0 {name=l4752 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 520 0 0 {name=XPR_1_II}
C {devices/lab_pin.sym} -780 510 0 0 {name=l4753 sig_type=std_logic lab=PL_1_II}
C {devices/lab_pin.sym} -780 530 0 0 {name=l4754 sig_type=std_logic lab=WL_1_II}
C {devices/lab_pin.sym} -620 510 0 0 {name=l4755 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 530 0 0 {name=l4756 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 740 0 0 {name=XLR_2_II}
C {devices/lab_pin.sym} -1080 720 0 0 {name=l4757 sig_type=std_logic lab=RSEL_2}
C {devices/lab_pin.sym} -1080 740 0 0 {name=l4758 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 760 0 0 {name=l4759 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 720 0 0 {name=l4760 sig_type=std_logic lab=WL_2_II}
C {devices/lab_pin.sym} -920 740 0 0 {name=l4761 sig_type=std_logic lab=RGB_2_II}
C {devices/lab_pin.sym} -920 760 0 0 {name=l4762 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 740 0 0 {name=XPR_2_II}
C {devices/lab_pin.sym} -780 730 0 0 {name=l4763 sig_type=std_logic lab=PL_2_II}
C {devices/lab_pin.sym} -780 750 0 0 {name=l4764 sig_type=std_logic lab=WL_2_II}
C {devices/lab_pin.sym} -620 730 0 0 {name=l4765 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 750 0 0 {name=l4766 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 960 0 0 {name=XLR_3_II}
C {devices/lab_pin.sym} -1080 940 0 0 {name=l4767 sig_type=std_logic lab=RSEL_3}
C {devices/lab_pin.sym} -1080 960 0 0 {name=l4768 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 980 0 0 {name=l4769 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 940 0 0 {name=l4770 sig_type=std_logic lab=WL_3_II}
C {devices/lab_pin.sym} -920 960 0 0 {name=l4771 sig_type=std_logic lab=RGB_3_II}
C {devices/lab_pin.sym} -920 980 0 0 {name=l4772 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 960 0 0 {name=XPR_3_II}
C {devices/lab_pin.sym} -780 950 0 0 {name=l4773 sig_type=std_logic lab=PL_3_II}
C {devices/lab_pin.sym} -780 970 0 0 {name=l4774 sig_type=std_logic lab=WL_3_II}
C {devices/lab_pin.sym} -620 950 0 0 {name=l4775 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 970 0 0 {name=l4776 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 1180 0 0 {name=XLR_4_II}
C {devices/lab_pin.sym} -1080 1160 0 0 {name=l4777 sig_type=std_logic lab=RSEL_4}
C {devices/lab_pin.sym} -1080 1180 0 0 {name=l4778 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 1200 0 0 {name=l4779 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 1160 0 0 {name=l4780 sig_type=std_logic lab=WL_4_II}
C {devices/lab_pin.sym} -920 1180 0 0 {name=l4781 sig_type=std_logic lab=RGB_4_II}
C {devices/lab_pin.sym} -920 1200 0 0 {name=l4782 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 1180 0 0 {name=XPR_4_II}
C {devices/lab_pin.sym} -780 1170 0 0 {name=l4783 sig_type=std_logic lab=PL_4_II}
C {devices/lab_pin.sym} -780 1190 0 0 {name=l4784 sig_type=std_logic lab=WL_4_II}
C {devices/lab_pin.sym} -620 1170 0 0 {name=l4785 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 1190 0 0 {name=l4786 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 1400 0 0 {name=XLR_5_II}
C {devices/lab_pin.sym} -1080 1380 0 0 {name=l4787 sig_type=std_logic lab=RSEL_5}
C {devices/lab_pin.sym} -1080 1400 0 0 {name=l4788 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 1420 0 0 {name=l4789 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 1380 0 0 {name=l4790 sig_type=std_logic lab=WL_5_II}
C {devices/lab_pin.sym} -920 1400 0 0 {name=l4791 sig_type=std_logic lab=RGB_5_II}
C {devices/lab_pin.sym} -920 1420 0 0 {name=l4792 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 1400 0 0 {name=XPR_5_II}
C {devices/lab_pin.sym} -780 1390 0 0 {name=l4793 sig_type=std_logic lab=PL_5_II}
C {devices/lab_pin.sym} -780 1410 0 0 {name=l4794 sig_type=std_logic lab=WL_5_II}
C {devices/lab_pin.sym} -620 1390 0 0 {name=l4795 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 1410 0 0 {name=l4796 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 1620 0 0 {name=XLR_6_II}
C {devices/lab_pin.sym} -1080 1600 0 0 {name=l4797 sig_type=std_logic lab=RSEL_6}
C {devices/lab_pin.sym} -1080 1620 0 0 {name=l4798 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 1640 0 0 {name=l4799 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 1600 0 0 {name=l4800 sig_type=std_logic lab=WL_6_II}
C {devices/lab_pin.sym} -920 1620 0 0 {name=l4801 sig_type=std_logic lab=RGB_6_II}
C {devices/lab_pin.sym} -920 1640 0 0 {name=l4802 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 1620 0 0 {name=XPR_6_II}
C {devices/lab_pin.sym} -780 1610 0 0 {name=l4803 sig_type=std_logic lab=PL_6_II}
C {devices/lab_pin.sym} -780 1630 0 0 {name=l4804 sig_type=std_logic lab=WL_6_II}
C {devices/lab_pin.sym} -620 1610 0 0 {name=l4805 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 1630 0 0 {name=l4806 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 1840 0 0 {name=XLR_7_II}
C {devices/lab_pin.sym} -1080 1820 0 0 {name=l4807 sig_type=std_logic lab=RSEL_7}
C {devices/lab_pin.sym} -1080 1840 0 0 {name=l4808 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 1860 0 0 {name=l4809 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 1820 0 0 {name=l4810 sig_type=std_logic lab=WL_7_II}
C {devices/lab_pin.sym} -920 1840 0 0 {name=l4811 sig_type=std_logic lab=RGB_7_II}
C {devices/lab_pin.sym} -920 1860 0 0 {name=l4812 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 1840 0 0 {name=XPR_7_II}
C {devices/lab_pin.sym} -780 1830 0 0 {name=l4813 sig_type=std_logic lab=PL_7_II}
C {devices/lab_pin.sym} -780 1850 0 0 {name=l4814 sig_type=std_logic lab=WL_7_II}
C {devices/lab_pin.sym} -620 1830 0 0 {name=l4815 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 1850 0 0 {name=l4816 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 2060 0 0 {name=XLR_8_II}
C {devices/lab_pin.sym} -1080 2040 0 0 {name=l4817 sig_type=std_logic lab=RSEL_8}
C {devices/lab_pin.sym} -1080 2060 0 0 {name=l4818 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 2080 0 0 {name=l4819 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 2040 0 0 {name=l4820 sig_type=std_logic lab=WL_8_II}
C {devices/lab_pin.sym} -920 2060 0 0 {name=l4821 sig_type=std_logic lab=RGB_8_II}
C {devices/lab_pin.sym} -920 2080 0 0 {name=l4822 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 2060 0 0 {name=XPR_8_II}
C {devices/lab_pin.sym} -780 2050 0 0 {name=l4823 sig_type=std_logic lab=PL_8_II}
C {devices/lab_pin.sym} -780 2070 0 0 {name=l4824 sig_type=std_logic lab=WL_8_II}
C {devices/lab_pin.sym} -620 2050 0 0 {name=l4825 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 2070 0 0 {name=l4826 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 2280 0 0 {name=XLR_9_II}
C {devices/lab_pin.sym} -1080 2260 0 0 {name=l4827 sig_type=std_logic lab=RSEL_9}
C {devices/lab_pin.sym} -1080 2280 0 0 {name=l4828 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 2300 0 0 {name=l4829 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 2260 0 0 {name=l4830 sig_type=std_logic lab=WL_9_II}
C {devices/lab_pin.sym} -920 2280 0 0 {name=l4831 sig_type=std_logic lab=RGB_9_II}
C {devices/lab_pin.sym} -920 2300 0 0 {name=l4832 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 2280 0 0 {name=XPR_9_II}
C {devices/lab_pin.sym} -780 2270 0 0 {name=l4833 sig_type=std_logic lab=PL_9_II}
C {devices/lab_pin.sym} -780 2290 0 0 {name=l4834 sig_type=std_logic lab=WL_9_II}
C {devices/lab_pin.sym} -620 2270 0 0 {name=l4835 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 2290 0 0 {name=l4836 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 2500 0 0 {name=XLR_10_II}
C {devices/lab_pin.sym} -1080 2480 0 0 {name=l4837 sig_type=std_logic lab=RSEL_10}
C {devices/lab_pin.sym} -1080 2500 0 0 {name=l4838 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 2520 0 0 {name=l4839 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 2480 0 0 {name=l4840 sig_type=std_logic lab=WL_10_II}
C {devices/lab_pin.sym} -920 2500 0 0 {name=l4841 sig_type=std_logic lab=RGB_10_II}
C {devices/lab_pin.sym} -920 2520 0 0 {name=l4842 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 2500 0 0 {name=XPR_10_II}
C {devices/lab_pin.sym} -780 2490 0 0 {name=l4843 sig_type=std_logic lab=PL_10_II}
C {devices/lab_pin.sym} -780 2510 0 0 {name=l4844 sig_type=std_logic lab=WL_10_II}
C {devices/lab_pin.sym} -620 2490 0 0 {name=l4845 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 2510 0 0 {name=l4846 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 2720 0 0 {name=XLR_11_II}
C {devices/lab_pin.sym} -1080 2700 0 0 {name=l4847 sig_type=std_logic lab=RSEL_11}
C {devices/lab_pin.sym} -1080 2720 0 0 {name=l4848 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 2740 0 0 {name=l4849 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 2700 0 0 {name=l4850 sig_type=std_logic lab=WL_11_II}
C {devices/lab_pin.sym} -920 2720 0 0 {name=l4851 sig_type=std_logic lab=RGB_11_II}
C {devices/lab_pin.sym} -920 2740 0 0 {name=l4852 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 2720 0 0 {name=XPR_11_II}
C {devices/lab_pin.sym} -780 2710 0 0 {name=l4853 sig_type=std_logic lab=PL_11_II}
C {devices/lab_pin.sym} -780 2730 0 0 {name=l4854 sig_type=std_logic lab=WL_11_II}
C {devices/lab_pin.sym} -620 2710 0 0 {name=l4855 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 2730 0 0 {name=l4856 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 2940 0 0 {name=XLR_12_II}
C {devices/lab_pin.sym} -1080 2920 0 0 {name=l4857 sig_type=std_logic lab=RSEL_12}
C {devices/lab_pin.sym} -1080 2940 0 0 {name=l4858 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 2960 0 0 {name=l4859 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 2920 0 0 {name=l4860 sig_type=std_logic lab=WL_12_II}
C {devices/lab_pin.sym} -920 2940 0 0 {name=l4861 sig_type=std_logic lab=RGB_12_II}
C {devices/lab_pin.sym} -920 2960 0 0 {name=l4862 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 2940 0 0 {name=XPR_12_II}
C {devices/lab_pin.sym} -780 2930 0 0 {name=l4863 sig_type=std_logic lab=PL_12_II}
C {devices/lab_pin.sym} -780 2950 0 0 {name=l4864 sig_type=std_logic lab=WL_12_II}
C {devices/lab_pin.sym} -620 2930 0 0 {name=l4865 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 2950 0 0 {name=l4866 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 3160 0 0 {name=XLR_13_II}
C {devices/lab_pin.sym} -1080 3140 0 0 {name=l4867 sig_type=std_logic lab=RSEL_13}
C {devices/lab_pin.sym} -1080 3160 0 0 {name=l4868 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 3180 0 0 {name=l4869 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 3140 0 0 {name=l4870 sig_type=std_logic lab=WL_13_II}
C {devices/lab_pin.sym} -920 3160 0 0 {name=l4871 sig_type=std_logic lab=RGB_13_II}
C {devices/lab_pin.sym} -920 3180 0 0 {name=l4872 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 3160 0 0 {name=XPR_13_II}
C {devices/lab_pin.sym} -780 3150 0 0 {name=l4873 sig_type=std_logic lab=PL_13_II}
C {devices/lab_pin.sym} -780 3170 0 0 {name=l4874 sig_type=std_logic lab=WL_13_II}
C {devices/lab_pin.sym} -620 3150 0 0 {name=l4875 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 3170 0 0 {name=l4876 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 3380 0 0 {name=XLR_14_II}
C {devices/lab_pin.sym} -1080 3360 0 0 {name=l4877 sig_type=std_logic lab=RSEL_14}
C {devices/lab_pin.sym} -1080 3380 0 0 {name=l4878 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 3400 0 0 {name=l4879 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 3360 0 0 {name=l4880 sig_type=std_logic lab=WL_14_II}
C {devices/lab_pin.sym} -920 3380 0 0 {name=l4881 sig_type=std_logic lab=RGB_14_II}
C {devices/lab_pin.sym} -920 3400 0 0 {name=l4882 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 3380 0 0 {name=XPR_14_II}
C {devices/lab_pin.sym} -780 3370 0 0 {name=l4883 sig_type=std_logic lab=PL_14_II}
C {devices/lab_pin.sym} -780 3390 0 0 {name=l4884 sig_type=std_logic lab=WL_14_II}
C {devices/lab_pin.sym} -620 3370 0 0 {name=l4885 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 3390 0 0 {name=l4886 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 3600 0 0 {name=XLR_15_II}
C {devices/lab_pin.sym} -1080 3580 0 0 {name=l4887 sig_type=std_logic lab=RSEL_15}
C {devices/lab_pin.sym} -1080 3600 0 0 {name=l4888 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 3620 0 0 {name=l4889 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 3580 0 0 {name=l4890 sig_type=std_logic lab=WL_15_II}
C {devices/lab_pin.sym} -920 3600 0 0 {name=l4891 sig_type=std_logic lab=RGB_15_II}
C {devices/lab_pin.sym} -920 3620 0 0 {name=l4892 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 3600 0 0 {name=XPR_15_II}
C {devices/lab_pin.sym} -780 3590 0 0 {name=l4893 sig_type=std_logic lab=PL_15_II}
C {devices/lab_pin.sym} -780 3610 0 0 {name=l4894 sig_type=std_logic lab=WL_15_II}
C {devices/lab_pin.sym} -620 3590 0 0 {name=l4895 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 3610 0 0 {name=l4896 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 3820 0 0 {name=XLR_16_II}
C {devices/lab_pin.sym} -1080 3800 0 0 {name=l4897 sig_type=std_logic lab=RSEL_16}
C {devices/lab_pin.sym} -1080 3820 0 0 {name=l4898 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 3840 0 0 {name=l4899 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 3800 0 0 {name=l4900 sig_type=std_logic lab=WL_16_II}
C {devices/lab_pin.sym} -920 3820 0 0 {name=l4901 sig_type=std_logic lab=RGB_16_II}
C {devices/lab_pin.sym} -920 3840 0 0 {name=l4902 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 3820 0 0 {name=XPR_16_II}
C {devices/lab_pin.sym} -780 3810 0 0 {name=l4903 sig_type=std_logic lab=PL_16_II}
C {devices/lab_pin.sym} -780 3830 0 0 {name=l4904 sig_type=std_logic lab=WL_16_II}
C {devices/lab_pin.sym} -620 3810 0 0 {name=l4905 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 3830 0 0 {name=l4906 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 4040 0 0 {name=XLR_17_II}
C {devices/lab_pin.sym} -1080 4020 0 0 {name=l4907 sig_type=std_logic lab=RSEL_17}
C {devices/lab_pin.sym} -1080 4040 0 0 {name=l4908 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 4060 0 0 {name=l4909 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 4020 0 0 {name=l4910 sig_type=std_logic lab=WL_17_II}
C {devices/lab_pin.sym} -920 4040 0 0 {name=l4911 sig_type=std_logic lab=RGB_17_II}
C {devices/lab_pin.sym} -920 4060 0 0 {name=l4912 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 4040 0 0 {name=XPR_17_II}
C {devices/lab_pin.sym} -780 4030 0 0 {name=l4913 sig_type=std_logic lab=PL_17_II}
C {devices/lab_pin.sym} -780 4050 0 0 {name=l4914 sig_type=std_logic lab=WL_17_II}
C {devices/lab_pin.sym} -620 4030 0 0 {name=l4915 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 4050 0 0 {name=l4916 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 4260 0 0 {name=XLR_18_II}
C {devices/lab_pin.sym} -1080 4240 0 0 {name=l4917 sig_type=std_logic lab=RSEL_18}
C {devices/lab_pin.sym} -1080 4260 0 0 {name=l4918 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 4280 0 0 {name=l4919 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 4240 0 0 {name=l4920 sig_type=std_logic lab=WL_18_II}
C {devices/lab_pin.sym} -920 4260 0 0 {name=l4921 sig_type=std_logic lab=RGB_18_II}
C {devices/lab_pin.sym} -920 4280 0 0 {name=l4922 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 4260 0 0 {name=XPR_18_II}
C {devices/lab_pin.sym} -780 4250 0 0 {name=l4923 sig_type=std_logic lab=PL_18_II}
C {devices/lab_pin.sym} -780 4270 0 0 {name=l4924 sig_type=std_logic lab=WL_18_II}
C {devices/lab_pin.sym} -620 4250 0 0 {name=l4925 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 4270 0 0 {name=l4926 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 4480 0 0 {name=XLR_19_II}
C {devices/lab_pin.sym} -1080 4460 0 0 {name=l4927 sig_type=std_logic lab=RSEL_19}
C {devices/lab_pin.sym} -1080 4480 0 0 {name=l4928 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 4500 0 0 {name=l4929 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 4460 0 0 {name=l4930 sig_type=std_logic lab=WL_19_II}
C {devices/lab_pin.sym} -920 4480 0 0 {name=l4931 sig_type=std_logic lab=RGB_19_II}
C {devices/lab_pin.sym} -920 4500 0 0 {name=l4932 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 4480 0 0 {name=XPR_19_II}
C {devices/lab_pin.sym} -780 4470 0 0 {name=l4933 sig_type=std_logic lab=PL_19_II}
C {devices/lab_pin.sym} -780 4490 0 0 {name=l4934 sig_type=std_logic lab=WL_19_II}
C {devices/lab_pin.sym} -620 4470 0 0 {name=l4935 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 4490 0 0 {name=l4936 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 4700 0 0 {name=XLR_20_II}
C {devices/lab_pin.sym} -1080 4680 0 0 {name=l4937 sig_type=std_logic lab=RSEL_20}
C {devices/lab_pin.sym} -1080 4700 0 0 {name=l4938 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 4720 0 0 {name=l4939 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 4680 0 0 {name=l4940 sig_type=std_logic lab=WL_20_II}
C {devices/lab_pin.sym} -920 4700 0 0 {name=l4941 sig_type=std_logic lab=RGB_20_II}
C {devices/lab_pin.sym} -920 4720 0 0 {name=l4942 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 4700 0 0 {name=XPR_20_II}
C {devices/lab_pin.sym} -780 4690 0 0 {name=l4943 sig_type=std_logic lab=PL_20_II}
C {devices/lab_pin.sym} -780 4710 0 0 {name=l4944 sig_type=std_logic lab=WL_20_II}
C {devices/lab_pin.sym} -620 4690 0 0 {name=l4945 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 4710 0 0 {name=l4946 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 4920 0 0 {name=XLR_21_II}
C {devices/lab_pin.sym} -1080 4900 0 0 {name=l4947 sig_type=std_logic lab=RSEL_21}
C {devices/lab_pin.sym} -1080 4920 0 0 {name=l4948 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 4940 0 0 {name=l4949 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 4900 0 0 {name=l4950 sig_type=std_logic lab=WL_21_II}
C {devices/lab_pin.sym} -920 4920 0 0 {name=l4951 sig_type=std_logic lab=RGB_21_II}
C {devices/lab_pin.sym} -920 4940 0 0 {name=l4952 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 4920 0 0 {name=XPR_21_II}
C {devices/lab_pin.sym} -780 4910 0 0 {name=l4953 sig_type=std_logic lab=PL_21_II}
C {devices/lab_pin.sym} -780 4930 0 0 {name=l4954 sig_type=std_logic lab=WL_21_II}
C {devices/lab_pin.sym} -620 4910 0 0 {name=l4955 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 4930 0 0 {name=l4956 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 5140 0 0 {name=XLR_22_II}
C {devices/lab_pin.sym} -1080 5120 0 0 {name=l4957 sig_type=std_logic lab=RSEL_22}
C {devices/lab_pin.sym} -1080 5140 0 0 {name=l4958 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 5160 0 0 {name=l4959 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 5120 0 0 {name=l4960 sig_type=std_logic lab=WL_22_II}
C {devices/lab_pin.sym} -920 5140 0 0 {name=l4961 sig_type=std_logic lab=RGB_22_II}
C {devices/lab_pin.sym} -920 5160 0 0 {name=l4962 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 5140 0 0 {name=XPR_22_II}
C {devices/lab_pin.sym} -780 5130 0 0 {name=l4963 sig_type=std_logic lab=PL_22_II}
C {devices/lab_pin.sym} -780 5150 0 0 {name=l4964 sig_type=std_logic lab=WL_22_II}
C {devices/lab_pin.sym} -620 5130 0 0 {name=l4965 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 5150 0 0 {name=l4966 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 5360 0 0 {name=XLR_23_II}
C {devices/lab_pin.sym} -1080 5340 0 0 {name=l4967 sig_type=std_logic lab=RSEL_23}
C {devices/lab_pin.sym} -1080 5360 0 0 {name=l4968 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 5380 0 0 {name=l4969 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 5340 0 0 {name=l4970 sig_type=std_logic lab=WL_23_II}
C {devices/lab_pin.sym} -920 5360 0 0 {name=l4971 sig_type=std_logic lab=RGB_23_II}
C {devices/lab_pin.sym} -920 5380 0 0 {name=l4972 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 5360 0 0 {name=XPR_23_II}
C {devices/lab_pin.sym} -780 5350 0 0 {name=l4973 sig_type=std_logic lab=PL_23_II}
C {devices/lab_pin.sym} -780 5370 0 0 {name=l4974 sig_type=std_logic lab=WL_23_II}
C {devices/lab_pin.sym} -620 5350 0 0 {name=l4975 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 5370 0 0 {name=l4976 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 5580 0 0 {name=XLR_24_II}
C {devices/lab_pin.sym} -1080 5560 0 0 {name=l4977 sig_type=std_logic lab=RSEL_24}
C {devices/lab_pin.sym} -1080 5580 0 0 {name=l4978 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 5600 0 0 {name=l4979 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 5560 0 0 {name=l4980 sig_type=std_logic lab=WL_24_II}
C {devices/lab_pin.sym} -920 5580 0 0 {name=l4981 sig_type=std_logic lab=RGB_24_II}
C {devices/lab_pin.sym} -920 5600 0 0 {name=l4982 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 5580 0 0 {name=XPR_24_II}
C {devices/lab_pin.sym} -780 5570 0 0 {name=l4983 sig_type=std_logic lab=PL_24_II}
C {devices/lab_pin.sym} -780 5590 0 0 {name=l4984 sig_type=std_logic lab=WL_24_II}
C {devices/lab_pin.sym} -620 5570 0 0 {name=l4985 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 5590 0 0 {name=l4986 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 5800 0 0 {name=XLR_25_II}
C {devices/lab_pin.sym} -1080 5780 0 0 {name=l4987 sig_type=std_logic lab=RSEL_25}
C {devices/lab_pin.sym} -1080 5800 0 0 {name=l4988 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 5820 0 0 {name=l4989 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 5780 0 0 {name=l4990 sig_type=std_logic lab=WL_25_II}
C {devices/lab_pin.sym} -920 5800 0 0 {name=l4991 sig_type=std_logic lab=RGB_25_II}
C {devices/lab_pin.sym} -920 5820 0 0 {name=l4992 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 5800 0 0 {name=XPR_25_II}
C {devices/lab_pin.sym} -780 5790 0 0 {name=l4993 sig_type=std_logic lab=PL_25_II}
C {devices/lab_pin.sym} -780 5810 0 0 {name=l4994 sig_type=std_logic lab=WL_25_II}
C {devices/lab_pin.sym} -620 5790 0 0 {name=l4995 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 5810 0 0 {name=l4996 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 6020 0 0 {name=XLR_26_II}
C {devices/lab_pin.sym} -1080 6000 0 0 {name=l4997 sig_type=std_logic lab=RSEL_26}
C {devices/lab_pin.sym} -1080 6020 0 0 {name=l4998 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 6040 0 0 {name=l4999 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 6000 0 0 {name=l5000 sig_type=std_logic lab=WL_26_II}
C {devices/lab_pin.sym} -920 6020 0 0 {name=l5001 sig_type=std_logic lab=RGB_26_II}
C {devices/lab_pin.sym} -920 6040 0 0 {name=l5002 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 6020 0 0 {name=XPR_26_II}
C {devices/lab_pin.sym} -780 6010 0 0 {name=l5003 sig_type=std_logic lab=PL_26_II}
C {devices/lab_pin.sym} -780 6030 0 0 {name=l5004 sig_type=std_logic lab=WL_26_II}
C {devices/lab_pin.sym} -620 6010 0 0 {name=l5005 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 6030 0 0 {name=l5006 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 6240 0 0 {name=XLR_27_II}
C {devices/lab_pin.sym} -1080 6220 0 0 {name=l5007 sig_type=std_logic lab=RSEL_27}
C {devices/lab_pin.sym} -1080 6240 0 0 {name=l5008 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 6260 0 0 {name=l5009 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 6220 0 0 {name=l5010 sig_type=std_logic lab=WL_27_II}
C {devices/lab_pin.sym} -920 6240 0 0 {name=l5011 sig_type=std_logic lab=RGB_27_II}
C {devices/lab_pin.sym} -920 6260 0 0 {name=l5012 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 6240 0 0 {name=XPR_27_II}
C {devices/lab_pin.sym} -780 6230 0 0 {name=l5013 sig_type=std_logic lab=PL_27_II}
C {devices/lab_pin.sym} -780 6250 0 0 {name=l5014 sig_type=std_logic lab=WL_27_II}
C {devices/lab_pin.sym} -620 6230 0 0 {name=l5015 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 6250 0 0 {name=l5016 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 6460 0 0 {name=XLR_28_II}
C {devices/lab_pin.sym} -1080 6440 0 0 {name=l5017 sig_type=std_logic lab=RSEL_28}
C {devices/lab_pin.sym} -1080 6460 0 0 {name=l5018 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 6480 0 0 {name=l5019 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 6440 0 0 {name=l5020 sig_type=std_logic lab=WL_28_II}
C {devices/lab_pin.sym} -920 6460 0 0 {name=l5021 sig_type=std_logic lab=RGB_28_II}
C {devices/lab_pin.sym} -920 6480 0 0 {name=l5022 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 6460 0 0 {name=XPR_28_II}
C {devices/lab_pin.sym} -780 6450 0 0 {name=l5023 sig_type=std_logic lab=PL_28_II}
C {devices/lab_pin.sym} -780 6470 0 0 {name=l5024 sig_type=std_logic lab=WL_28_II}
C {devices/lab_pin.sym} -620 6450 0 0 {name=l5025 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 6470 0 0 {name=l5026 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 6680 0 0 {name=XLR_29_II}
C {devices/lab_pin.sym} -1080 6660 0 0 {name=l5027 sig_type=std_logic lab=RSEL_29}
C {devices/lab_pin.sym} -1080 6680 0 0 {name=l5028 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 6700 0 0 {name=l5029 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 6660 0 0 {name=l5030 sig_type=std_logic lab=WL_29_II}
C {devices/lab_pin.sym} -920 6680 0 0 {name=l5031 sig_type=std_logic lab=RGB_29_II}
C {devices/lab_pin.sym} -920 6700 0 0 {name=l5032 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 6680 0 0 {name=XPR_29_II}
C {devices/lab_pin.sym} -780 6670 0 0 {name=l5033 sig_type=std_logic lab=PL_29_II}
C {devices/lab_pin.sym} -780 6690 0 0 {name=l5034 sig_type=std_logic lab=WL_29_II}
C {devices/lab_pin.sym} -620 6670 0 0 {name=l5035 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 6690 0 0 {name=l5036 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 6900 0 0 {name=XLR_30_II}
C {devices/lab_pin.sym} -1080 6880 0 0 {name=l5037 sig_type=std_logic lab=RSEL_30}
C {devices/lab_pin.sym} -1080 6900 0 0 {name=l5038 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 6920 0 0 {name=l5039 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 6880 0 0 {name=l5040 sig_type=std_logic lab=WL_30_II}
C {devices/lab_pin.sym} -920 6900 0 0 {name=l5041 sig_type=std_logic lab=RGB_30_II}
C {devices/lab_pin.sym} -920 6920 0 0 {name=l5042 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 6900 0 0 {name=XPR_30_II}
C {devices/lab_pin.sym} -780 6890 0 0 {name=l5043 sig_type=std_logic lab=PL_30_II}
C {devices/lab_pin.sym} -780 6910 0 0 {name=l5044 sig_type=std_logic lab=WL_30_II}
C {devices/lab_pin.sym} -620 6890 0 0 {name=l5045 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 6910 0 0 {name=l5046 sig_type=std_logic lab=VSS}
C {ls_hv10.sym} -1000 7120 0 0 {name=XLR_31_II}
C {devices/lab_pin.sym} -1080 7100 0 0 {name=l5047 sig_type=std_logic lab=RSEL_31}
C {devices/lab_pin.sym} -1080 7120 0 0 {name=l5048 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1080 7140 0 0 {name=l5049 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -920 7100 0 0 {name=l5050 sig_type=std_logic lab=WL_31_II}
C {devices/lab_pin.sym} -920 7120 0 0 {name=l5051 sig_type=std_logic lab=RGB_31_II}
C {devices/lab_pin.sym} -920 7140 0 0 {name=l5052 sig_type=std_logic lab=VDDH_II}
C {pg_n10.sym} -700 7120 0 0 {name=XPR_31_II}
C {devices/lab_pin.sym} -780 7110 0 0 {name=l5053 sig_type=std_logic lab=PL_31_II}
C {devices/lab_pin.sym} -780 7130 0 0 {name=l5054 sig_type=std_logic lab=WL_31_II}
C {devices/lab_pin.sym} -620 7110 0 0 {name=l5055 sig_type=std_logic lab=PLG_II}
C {devices/lab_pin.sym} -620 7130 0 0 {name=l5056 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 300 0 0 {name=XLR_0_III}
C {devices/lab_pin.sym} -1780 280 0 0 {name=l5057 sig_type=std_logic lab=RSEL_0}
C {devices/lab_pin.sym} -1780 300 0 0 {name=l5058 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 320 0 0 {name=l5059 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 280 0 0 {name=l5060 sig_type=std_logic lab=RG_0_III}
C {devices/lab_pin.sym} -1620 300 0 0 {name=l5061 sig_type=std_logic lab=WL_0_III}
C {devices/lab_pin.sym} -1620 320 0 0 {name=l5062 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 300 0 0 {name=XPR_0_III}
C {devices/lab_pin.sym} -1480 290 0 0 {name=l5063 sig_type=std_logic lab=PL_0_III}
C {devices/lab_pin.sym} -1480 310 0 0 {name=l5064 sig_type=std_logic lab=RG_0_III}
C {devices/lab_pin.sym} -1320 290 0 0 {name=l5065 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 310 0 0 {name=l5066 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 520 0 0 {name=XLR_1_III}
C {devices/lab_pin.sym} -1780 500 0 0 {name=l5067 sig_type=std_logic lab=RSEL_1}
C {devices/lab_pin.sym} -1780 520 0 0 {name=l5068 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 540 0 0 {name=l5069 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 500 0 0 {name=l5070 sig_type=std_logic lab=RG_1_III}
C {devices/lab_pin.sym} -1620 520 0 0 {name=l5071 sig_type=std_logic lab=WL_1_III}
C {devices/lab_pin.sym} -1620 540 0 0 {name=l5072 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 520 0 0 {name=XPR_1_III}
C {devices/lab_pin.sym} -1480 510 0 0 {name=l5073 sig_type=std_logic lab=PL_1_III}
C {devices/lab_pin.sym} -1480 530 0 0 {name=l5074 sig_type=std_logic lab=RG_1_III}
C {devices/lab_pin.sym} -1320 510 0 0 {name=l5075 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 530 0 0 {name=l5076 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 740 0 0 {name=XLR_2_III}
C {devices/lab_pin.sym} -1780 720 0 0 {name=l5077 sig_type=std_logic lab=RSEL_2}
C {devices/lab_pin.sym} -1780 740 0 0 {name=l5078 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 760 0 0 {name=l5079 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 720 0 0 {name=l5080 sig_type=std_logic lab=RG_2_III}
C {devices/lab_pin.sym} -1620 740 0 0 {name=l5081 sig_type=std_logic lab=WL_2_III}
C {devices/lab_pin.sym} -1620 760 0 0 {name=l5082 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 740 0 0 {name=XPR_2_III}
C {devices/lab_pin.sym} -1480 730 0 0 {name=l5083 sig_type=std_logic lab=PL_2_III}
C {devices/lab_pin.sym} -1480 750 0 0 {name=l5084 sig_type=std_logic lab=RG_2_III}
C {devices/lab_pin.sym} -1320 730 0 0 {name=l5085 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 750 0 0 {name=l5086 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 960 0 0 {name=XLR_3_III}
C {devices/lab_pin.sym} -1780 940 0 0 {name=l5087 sig_type=std_logic lab=RSEL_3}
C {devices/lab_pin.sym} -1780 960 0 0 {name=l5088 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 980 0 0 {name=l5089 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 940 0 0 {name=l5090 sig_type=std_logic lab=RG_3_III}
C {devices/lab_pin.sym} -1620 960 0 0 {name=l5091 sig_type=std_logic lab=WL_3_III}
C {devices/lab_pin.sym} -1620 980 0 0 {name=l5092 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 960 0 0 {name=XPR_3_III}
C {devices/lab_pin.sym} -1480 950 0 0 {name=l5093 sig_type=std_logic lab=PL_3_III}
C {devices/lab_pin.sym} -1480 970 0 0 {name=l5094 sig_type=std_logic lab=RG_3_III}
C {devices/lab_pin.sym} -1320 950 0 0 {name=l5095 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 970 0 0 {name=l5096 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 1180 0 0 {name=XLR_4_III}
C {devices/lab_pin.sym} -1780 1160 0 0 {name=l5097 sig_type=std_logic lab=RSEL_4}
C {devices/lab_pin.sym} -1780 1180 0 0 {name=l5098 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 1200 0 0 {name=l5099 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 1160 0 0 {name=l5100 sig_type=std_logic lab=RG_4_III}
C {devices/lab_pin.sym} -1620 1180 0 0 {name=l5101 sig_type=std_logic lab=WL_4_III}
C {devices/lab_pin.sym} -1620 1200 0 0 {name=l5102 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 1180 0 0 {name=XPR_4_III}
C {devices/lab_pin.sym} -1480 1170 0 0 {name=l5103 sig_type=std_logic lab=PL_4_III}
C {devices/lab_pin.sym} -1480 1190 0 0 {name=l5104 sig_type=std_logic lab=RG_4_III}
C {devices/lab_pin.sym} -1320 1170 0 0 {name=l5105 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 1190 0 0 {name=l5106 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 1400 0 0 {name=XLR_5_III}
C {devices/lab_pin.sym} -1780 1380 0 0 {name=l5107 sig_type=std_logic lab=RSEL_5}
C {devices/lab_pin.sym} -1780 1400 0 0 {name=l5108 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 1420 0 0 {name=l5109 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 1380 0 0 {name=l5110 sig_type=std_logic lab=RG_5_III}
C {devices/lab_pin.sym} -1620 1400 0 0 {name=l5111 sig_type=std_logic lab=WL_5_III}
C {devices/lab_pin.sym} -1620 1420 0 0 {name=l5112 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 1400 0 0 {name=XPR_5_III}
C {devices/lab_pin.sym} -1480 1390 0 0 {name=l5113 sig_type=std_logic lab=PL_5_III}
C {devices/lab_pin.sym} -1480 1410 0 0 {name=l5114 sig_type=std_logic lab=RG_5_III}
C {devices/lab_pin.sym} -1320 1390 0 0 {name=l5115 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 1410 0 0 {name=l5116 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 1620 0 0 {name=XLR_6_III}
C {devices/lab_pin.sym} -1780 1600 0 0 {name=l5117 sig_type=std_logic lab=RSEL_6}
C {devices/lab_pin.sym} -1780 1620 0 0 {name=l5118 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 1640 0 0 {name=l5119 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 1600 0 0 {name=l5120 sig_type=std_logic lab=RG_6_III}
C {devices/lab_pin.sym} -1620 1620 0 0 {name=l5121 sig_type=std_logic lab=WL_6_III}
C {devices/lab_pin.sym} -1620 1640 0 0 {name=l5122 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 1620 0 0 {name=XPR_6_III}
C {devices/lab_pin.sym} -1480 1610 0 0 {name=l5123 sig_type=std_logic lab=PL_6_III}
C {devices/lab_pin.sym} -1480 1630 0 0 {name=l5124 sig_type=std_logic lab=RG_6_III}
C {devices/lab_pin.sym} -1320 1610 0 0 {name=l5125 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 1630 0 0 {name=l5126 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 1840 0 0 {name=XLR_7_III}
C {devices/lab_pin.sym} -1780 1820 0 0 {name=l5127 sig_type=std_logic lab=RSEL_7}
C {devices/lab_pin.sym} -1780 1840 0 0 {name=l5128 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 1860 0 0 {name=l5129 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 1820 0 0 {name=l5130 sig_type=std_logic lab=RG_7_III}
C {devices/lab_pin.sym} -1620 1840 0 0 {name=l5131 sig_type=std_logic lab=WL_7_III}
C {devices/lab_pin.sym} -1620 1860 0 0 {name=l5132 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 1840 0 0 {name=XPR_7_III}
C {devices/lab_pin.sym} -1480 1830 0 0 {name=l5133 sig_type=std_logic lab=PL_7_III}
C {devices/lab_pin.sym} -1480 1850 0 0 {name=l5134 sig_type=std_logic lab=RG_7_III}
C {devices/lab_pin.sym} -1320 1830 0 0 {name=l5135 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 1850 0 0 {name=l5136 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 2060 0 0 {name=XLR_8_III}
C {devices/lab_pin.sym} -1780 2040 0 0 {name=l5137 sig_type=std_logic lab=RSEL_8}
C {devices/lab_pin.sym} -1780 2060 0 0 {name=l5138 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 2080 0 0 {name=l5139 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 2040 0 0 {name=l5140 sig_type=std_logic lab=RG_8_III}
C {devices/lab_pin.sym} -1620 2060 0 0 {name=l5141 sig_type=std_logic lab=WL_8_III}
C {devices/lab_pin.sym} -1620 2080 0 0 {name=l5142 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 2060 0 0 {name=XPR_8_III}
C {devices/lab_pin.sym} -1480 2050 0 0 {name=l5143 sig_type=std_logic lab=PL_8_III}
C {devices/lab_pin.sym} -1480 2070 0 0 {name=l5144 sig_type=std_logic lab=RG_8_III}
C {devices/lab_pin.sym} -1320 2050 0 0 {name=l5145 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 2070 0 0 {name=l5146 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 2280 0 0 {name=XLR_9_III}
C {devices/lab_pin.sym} -1780 2260 0 0 {name=l5147 sig_type=std_logic lab=RSEL_9}
C {devices/lab_pin.sym} -1780 2280 0 0 {name=l5148 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 2300 0 0 {name=l5149 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 2260 0 0 {name=l5150 sig_type=std_logic lab=RG_9_III}
C {devices/lab_pin.sym} -1620 2280 0 0 {name=l5151 sig_type=std_logic lab=WL_9_III}
C {devices/lab_pin.sym} -1620 2300 0 0 {name=l5152 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 2280 0 0 {name=XPR_9_III}
C {devices/lab_pin.sym} -1480 2270 0 0 {name=l5153 sig_type=std_logic lab=PL_9_III}
C {devices/lab_pin.sym} -1480 2290 0 0 {name=l5154 sig_type=std_logic lab=RG_9_III}
C {devices/lab_pin.sym} -1320 2270 0 0 {name=l5155 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 2290 0 0 {name=l5156 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 2500 0 0 {name=XLR_10_III}
C {devices/lab_pin.sym} -1780 2480 0 0 {name=l5157 sig_type=std_logic lab=RSEL_10}
C {devices/lab_pin.sym} -1780 2500 0 0 {name=l5158 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 2520 0 0 {name=l5159 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 2480 0 0 {name=l5160 sig_type=std_logic lab=RG_10_III}
C {devices/lab_pin.sym} -1620 2500 0 0 {name=l5161 sig_type=std_logic lab=WL_10_III}
C {devices/lab_pin.sym} -1620 2520 0 0 {name=l5162 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 2500 0 0 {name=XPR_10_III}
C {devices/lab_pin.sym} -1480 2490 0 0 {name=l5163 sig_type=std_logic lab=PL_10_III}
C {devices/lab_pin.sym} -1480 2510 0 0 {name=l5164 sig_type=std_logic lab=RG_10_III}
C {devices/lab_pin.sym} -1320 2490 0 0 {name=l5165 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 2510 0 0 {name=l5166 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 2720 0 0 {name=XLR_11_III}
C {devices/lab_pin.sym} -1780 2700 0 0 {name=l5167 sig_type=std_logic lab=RSEL_11}
C {devices/lab_pin.sym} -1780 2720 0 0 {name=l5168 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 2740 0 0 {name=l5169 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 2700 0 0 {name=l5170 sig_type=std_logic lab=RG_11_III}
C {devices/lab_pin.sym} -1620 2720 0 0 {name=l5171 sig_type=std_logic lab=WL_11_III}
C {devices/lab_pin.sym} -1620 2740 0 0 {name=l5172 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 2720 0 0 {name=XPR_11_III}
C {devices/lab_pin.sym} -1480 2710 0 0 {name=l5173 sig_type=std_logic lab=PL_11_III}
C {devices/lab_pin.sym} -1480 2730 0 0 {name=l5174 sig_type=std_logic lab=RG_11_III}
C {devices/lab_pin.sym} -1320 2710 0 0 {name=l5175 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 2730 0 0 {name=l5176 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 2940 0 0 {name=XLR_12_III}
C {devices/lab_pin.sym} -1780 2920 0 0 {name=l5177 sig_type=std_logic lab=RSEL_12}
C {devices/lab_pin.sym} -1780 2940 0 0 {name=l5178 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 2960 0 0 {name=l5179 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 2920 0 0 {name=l5180 sig_type=std_logic lab=RG_12_III}
C {devices/lab_pin.sym} -1620 2940 0 0 {name=l5181 sig_type=std_logic lab=WL_12_III}
C {devices/lab_pin.sym} -1620 2960 0 0 {name=l5182 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 2940 0 0 {name=XPR_12_III}
C {devices/lab_pin.sym} -1480 2930 0 0 {name=l5183 sig_type=std_logic lab=PL_12_III}
C {devices/lab_pin.sym} -1480 2950 0 0 {name=l5184 sig_type=std_logic lab=RG_12_III}
C {devices/lab_pin.sym} -1320 2930 0 0 {name=l5185 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 2950 0 0 {name=l5186 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 3160 0 0 {name=XLR_13_III}
C {devices/lab_pin.sym} -1780 3140 0 0 {name=l5187 sig_type=std_logic lab=RSEL_13}
C {devices/lab_pin.sym} -1780 3160 0 0 {name=l5188 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 3180 0 0 {name=l5189 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 3140 0 0 {name=l5190 sig_type=std_logic lab=RG_13_III}
C {devices/lab_pin.sym} -1620 3160 0 0 {name=l5191 sig_type=std_logic lab=WL_13_III}
C {devices/lab_pin.sym} -1620 3180 0 0 {name=l5192 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 3160 0 0 {name=XPR_13_III}
C {devices/lab_pin.sym} -1480 3150 0 0 {name=l5193 sig_type=std_logic lab=PL_13_III}
C {devices/lab_pin.sym} -1480 3170 0 0 {name=l5194 sig_type=std_logic lab=RG_13_III}
C {devices/lab_pin.sym} -1320 3150 0 0 {name=l5195 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 3170 0 0 {name=l5196 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 3380 0 0 {name=XLR_14_III}
C {devices/lab_pin.sym} -1780 3360 0 0 {name=l5197 sig_type=std_logic lab=RSEL_14}
C {devices/lab_pin.sym} -1780 3380 0 0 {name=l5198 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 3400 0 0 {name=l5199 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 3360 0 0 {name=l5200 sig_type=std_logic lab=RG_14_III}
C {devices/lab_pin.sym} -1620 3380 0 0 {name=l5201 sig_type=std_logic lab=WL_14_III}
C {devices/lab_pin.sym} -1620 3400 0 0 {name=l5202 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 3380 0 0 {name=XPR_14_III}
C {devices/lab_pin.sym} -1480 3370 0 0 {name=l5203 sig_type=std_logic lab=PL_14_III}
C {devices/lab_pin.sym} -1480 3390 0 0 {name=l5204 sig_type=std_logic lab=RG_14_III}
C {devices/lab_pin.sym} -1320 3370 0 0 {name=l5205 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 3390 0 0 {name=l5206 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 3600 0 0 {name=XLR_15_III}
C {devices/lab_pin.sym} -1780 3580 0 0 {name=l5207 sig_type=std_logic lab=RSEL_15}
C {devices/lab_pin.sym} -1780 3600 0 0 {name=l5208 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 3620 0 0 {name=l5209 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 3580 0 0 {name=l5210 sig_type=std_logic lab=RG_15_III}
C {devices/lab_pin.sym} -1620 3600 0 0 {name=l5211 sig_type=std_logic lab=WL_15_III}
C {devices/lab_pin.sym} -1620 3620 0 0 {name=l5212 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 3600 0 0 {name=XPR_15_III}
C {devices/lab_pin.sym} -1480 3590 0 0 {name=l5213 sig_type=std_logic lab=PL_15_III}
C {devices/lab_pin.sym} -1480 3610 0 0 {name=l5214 sig_type=std_logic lab=RG_15_III}
C {devices/lab_pin.sym} -1320 3590 0 0 {name=l5215 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 3610 0 0 {name=l5216 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 3820 0 0 {name=XLR_16_III}
C {devices/lab_pin.sym} -1780 3800 0 0 {name=l5217 sig_type=std_logic lab=RSEL_16}
C {devices/lab_pin.sym} -1780 3820 0 0 {name=l5218 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 3840 0 0 {name=l5219 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 3800 0 0 {name=l5220 sig_type=std_logic lab=RG_16_III}
C {devices/lab_pin.sym} -1620 3820 0 0 {name=l5221 sig_type=std_logic lab=WL_16_III}
C {devices/lab_pin.sym} -1620 3840 0 0 {name=l5222 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 3820 0 0 {name=XPR_16_III}
C {devices/lab_pin.sym} -1480 3810 0 0 {name=l5223 sig_type=std_logic lab=PL_16_III}
C {devices/lab_pin.sym} -1480 3830 0 0 {name=l5224 sig_type=std_logic lab=RG_16_III}
C {devices/lab_pin.sym} -1320 3810 0 0 {name=l5225 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 3830 0 0 {name=l5226 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 4040 0 0 {name=XLR_17_III}
C {devices/lab_pin.sym} -1780 4020 0 0 {name=l5227 sig_type=std_logic lab=RSEL_17}
C {devices/lab_pin.sym} -1780 4040 0 0 {name=l5228 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 4060 0 0 {name=l5229 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 4020 0 0 {name=l5230 sig_type=std_logic lab=RG_17_III}
C {devices/lab_pin.sym} -1620 4040 0 0 {name=l5231 sig_type=std_logic lab=WL_17_III}
C {devices/lab_pin.sym} -1620 4060 0 0 {name=l5232 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 4040 0 0 {name=XPR_17_III}
C {devices/lab_pin.sym} -1480 4030 0 0 {name=l5233 sig_type=std_logic lab=PL_17_III}
C {devices/lab_pin.sym} -1480 4050 0 0 {name=l5234 sig_type=std_logic lab=RG_17_III}
C {devices/lab_pin.sym} -1320 4030 0 0 {name=l5235 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 4050 0 0 {name=l5236 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 4260 0 0 {name=XLR_18_III}
C {devices/lab_pin.sym} -1780 4240 0 0 {name=l5237 sig_type=std_logic lab=RSEL_18}
C {devices/lab_pin.sym} -1780 4260 0 0 {name=l5238 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 4280 0 0 {name=l5239 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 4240 0 0 {name=l5240 sig_type=std_logic lab=RG_18_III}
C {devices/lab_pin.sym} -1620 4260 0 0 {name=l5241 sig_type=std_logic lab=WL_18_III}
C {devices/lab_pin.sym} -1620 4280 0 0 {name=l5242 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 4260 0 0 {name=XPR_18_III}
C {devices/lab_pin.sym} -1480 4250 0 0 {name=l5243 sig_type=std_logic lab=PL_18_III}
C {devices/lab_pin.sym} -1480 4270 0 0 {name=l5244 sig_type=std_logic lab=RG_18_III}
C {devices/lab_pin.sym} -1320 4250 0 0 {name=l5245 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 4270 0 0 {name=l5246 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 4480 0 0 {name=XLR_19_III}
C {devices/lab_pin.sym} -1780 4460 0 0 {name=l5247 sig_type=std_logic lab=RSEL_19}
C {devices/lab_pin.sym} -1780 4480 0 0 {name=l5248 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 4500 0 0 {name=l5249 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 4460 0 0 {name=l5250 sig_type=std_logic lab=RG_19_III}
C {devices/lab_pin.sym} -1620 4480 0 0 {name=l5251 sig_type=std_logic lab=WL_19_III}
C {devices/lab_pin.sym} -1620 4500 0 0 {name=l5252 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 4480 0 0 {name=XPR_19_III}
C {devices/lab_pin.sym} -1480 4470 0 0 {name=l5253 sig_type=std_logic lab=PL_19_III}
C {devices/lab_pin.sym} -1480 4490 0 0 {name=l5254 sig_type=std_logic lab=RG_19_III}
C {devices/lab_pin.sym} -1320 4470 0 0 {name=l5255 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 4490 0 0 {name=l5256 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 4700 0 0 {name=XLR_20_III}
C {devices/lab_pin.sym} -1780 4680 0 0 {name=l5257 sig_type=std_logic lab=RSEL_20}
C {devices/lab_pin.sym} -1780 4700 0 0 {name=l5258 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 4720 0 0 {name=l5259 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 4680 0 0 {name=l5260 sig_type=std_logic lab=RG_20_III}
C {devices/lab_pin.sym} -1620 4700 0 0 {name=l5261 sig_type=std_logic lab=WL_20_III}
C {devices/lab_pin.sym} -1620 4720 0 0 {name=l5262 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 4700 0 0 {name=XPR_20_III}
C {devices/lab_pin.sym} -1480 4690 0 0 {name=l5263 sig_type=std_logic lab=PL_20_III}
C {devices/lab_pin.sym} -1480 4710 0 0 {name=l5264 sig_type=std_logic lab=RG_20_III}
C {devices/lab_pin.sym} -1320 4690 0 0 {name=l5265 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 4710 0 0 {name=l5266 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 4920 0 0 {name=XLR_21_III}
C {devices/lab_pin.sym} -1780 4900 0 0 {name=l5267 sig_type=std_logic lab=RSEL_21}
C {devices/lab_pin.sym} -1780 4920 0 0 {name=l5268 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 4940 0 0 {name=l5269 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 4900 0 0 {name=l5270 sig_type=std_logic lab=RG_21_III}
C {devices/lab_pin.sym} -1620 4920 0 0 {name=l5271 sig_type=std_logic lab=WL_21_III}
C {devices/lab_pin.sym} -1620 4940 0 0 {name=l5272 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 4920 0 0 {name=XPR_21_III}
C {devices/lab_pin.sym} -1480 4910 0 0 {name=l5273 sig_type=std_logic lab=PL_21_III}
C {devices/lab_pin.sym} -1480 4930 0 0 {name=l5274 sig_type=std_logic lab=RG_21_III}
C {devices/lab_pin.sym} -1320 4910 0 0 {name=l5275 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 4930 0 0 {name=l5276 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 5140 0 0 {name=XLR_22_III}
C {devices/lab_pin.sym} -1780 5120 0 0 {name=l5277 sig_type=std_logic lab=RSEL_22}
C {devices/lab_pin.sym} -1780 5140 0 0 {name=l5278 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 5160 0 0 {name=l5279 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 5120 0 0 {name=l5280 sig_type=std_logic lab=RG_22_III}
C {devices/lab_pin.sym} -1620 5140 0 0 {name=l5281 sig_type=std_logic lab=WL_22_III}
C {devices/lab_pin.sym} -1620 5160 0 0 {name=l5282 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 5140 0 0 {name=XPR_22_III}
C {devices/lab_pin.sym} -1480 5130 0 0 {name=l5283 sig_type=std_logic lab=PL_22_III}
C {devices/lab_pin.sym} -1480 5150 0 0 {name=l5284 sig_type=std_logic lab=RG_22_III}
C {devices/lab_pin.sym} -1320 5130 0 0 {name=l5285 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 5150 0 0 {name=l5286 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 5360 0 0 {name=XLR_23_III}
C {devices/lab_pin.sym} -1780 5340 0 0 {name=l5287 sig_type=std_logic lab=RSEL_23}
C {devices/lab_pin.sym} -1780 5360 0 0 {name=l5288 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 5380 0 0 {name=l5289 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 5340 0 0 {name=l5290 sig_type=std_logic lab=RG_23_III}
C {devices/lab_pin.sym} -1620 5360 0 0 {name=l5291 sig_type=std_logic lab=WL_23_III}
C {devices/lab_pin.sym} -1620 5380 0 0 {name=l5292 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 5360 0 0 {name=XPR_23_III}
C {devices/lab_pin.sym} -1480 5350 0 0 {name=l5293 sig_type=std_logic lab=PL_23_III}
C {devices/lab_pin.sym} -1480 5370 0 0 {name=l5294 sig_type=std_logic lab=RG_23_III}
C {devices/lab_pin.sym} -1320 5350 0 0 {name=l5295 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 5370 0 0 {name=l5296 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 5580 0 0 {name=XLR_24_III}
C {devices/lab_pin.sym} -1780 5560 0 0 {name=l5297 sig_type=std_logic lab=RSEL_24}
C {devices/lab_pin.sym} -1780 5580 0 0 {name=l5298 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 5600 0 0 {name=l5299 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 5560 0 0 {name=l5300 sig_type=std_logic lab=RG_24_III}
C {devices/lab_pin.sym} -1620 5580 0 0 {name=l5301 sig_type=std_logic lab=WL_24_III}
C {devices/lab_pin.sym} -1620 5600 0 0 {name=l5302 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 5580 0 0 {name=XPR_24_III}
C {devices/lab_pin.sym} -1480 5570 0 0 {name=l5303 sig_type=std_logic lab=PL_24_III}
C {devices/lab_pin.sym} -1480 5590 0 0 {name=l5304 sig_type=std_logic lab=RG_24_III}
C {devices/lab_pin.sym} -1320 5570 0 0 {name=l5305 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 5590 0 0 {name=l5306 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 5800 0 0 {name=XLR_25_III}
C {devices/lab_pin.sym} -1780 5780 0 0 {name=l5307 sig_type=std_logic lab=RSEL_25}
C {devices/lab_pin.sym} -1780 5800 0 0 {name=l5308 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 5820 0 0 {name=l5309 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 5780 0 0 {name=l5310 sig_type=std_logic lab=RG_25_III}
C {devices/lab_pin.sym} -1620 5800 0 0 {name=l5311 sig_type=std_logic lab=WL_25_III}
C {devices/lab_pin.sym} -1620 5820 0 0 {name=l5312 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 5800 0 0 {name=XPR_25_III}
C {devices/lab_pin.sym} -1480 5790 0 0 {name=l5313 sig_type=std_logic lab=PL_25_III}
C {devices/lab_pin.sym} -1480 5810 0 0 {name=l5314 sig_type=std_logic lab=RG_25_III}
C {devices/lab_pin.sym} -1320 5790 0 0 {name=l5315 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 5810 0 0 {name=l5316 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 6020 0 0 {name=XLR_26_III}
C {devices/lab_pin.sym} -1780 6000 0 0 {name=l5317 sig_type=std_logic lab=RSEL_26}
C {devices/lab_pin.sym} -1780 6020 0 0 {name=l5318 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 6040 0 0 {name=l5319 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 6000 0 0 {name=l5320 sig_type=std_logic lab=RG_26_III}
C {devices/lab_pin.sym} -1620 6020 0 0 {name=l5321 sig_type=std_logic lab=WL_26_III}
C {devices/lab_pin.sym} -1620 6040 0 0 {name=l5322 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 6020 0 0 {name=XPR_26_III}
C {devices/lab_pin.sym} -1480 6010 0 0 {name=l5323 sig_type=std_logic lab=PL_26_III}
C {devices/lab_pin.sym} -1480 6030 0 0 {name=l5324 sig_type=std_logic lab=RG_26_III}
C {devices/lab_pin.sym} -1320 6010 0 0 {name=l5325 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 6030 0 0 {name=l5326 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 6240 0 0 {name=XLR_27_III}
C {devices/lab_pin.sym} -1780 6220 0 0 {name=l5327 sig_type=std_logic lab=RSEL_27}
C {devices/lab_pin.sym} -1780 6240 0 0 {name=l5328 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 6260 0 0 {name=l5329 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 6220 0 0 {name=l5330 sig_type=std_logic lab=RG_27_III}
C {devices/lab_pin.sym} -1620 6240 0 0 {name=l5331 sig_type=std_logic lab=WL_27_III}
C {devices/lab_pin.sym} -1620 6260 0 0 {name=l5332 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 6240 0 0 {name=XPR_27_III}
C {devices/lab_pin.sym} -1480 6230 0 0 {name=l5333 sig_type=std_logic lab=PL_27_III}
C {devices/lab_pin.sym} -1480 6250 0 0 {name=l5334 sig_type=std_logic lab=RG_27_III}
C {devices/lab_pin.sym} -1320 6230 0 0 {name=l5335 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 6250 0 0 {name=l5336 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 6460 0 0 {name=XLR_28_III}
C {devices/lab_pin.sym} -1780 6440 0 0 {name=l5337 sig_type=std_logic lab=RSEL_28}
C {devices/lab_pin.sym} -1780 6460 0 0 {name=l5338 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 6480 0 0 {name=l5339 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 6440 0 0 {name=l5340 sig_type=std_logic lab=RG_28_III}
C {devices/lab_pin.sym} -1620 6460 0 0 {name=l5341 sig_type=std_logic lab=WL_28_III}
C {devices/lab_pin.sym} -1620 6480 0 0 {name=l5342 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 6460 0 0 {name=XPR_28_III}
C {devices/lab_pin.sym} -1480 6450 0 0 {name=l5343 sig_type=std_logic lab=PL_28_III}
C {devices/lab_pin.sym} -1480 6470 0 0 {name=l5344 sig_type=std_logic lab=RG_28_III}
C {devices/lab_pin.sym} -1320 6450 0 0 {name=l5345 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 6470 0 0 {name=l5346 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 6680 0 0 {name=XLR_29_III}
C {devices/lab_pin.sym} -1780 6660 0 0 {name=l5347 sig_type=std_logic lab=RSEL_29}
C {devices/lab_pin.sym} -1780 6680 0 0 {name=l5348 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 6700 0 0 {name=l5349 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 6660 0 0 {name=l5350 sig_type=std_logic lab=RG_29_III}
C {devices/lab_pin.sym} -1620 6680 0 0 {name=l5351 sig_type=std_logic lab=WL_29_III}
C {devices/lab_pin.sym} -1620 6700 0 0 {name=l5352 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 6680 0 0 {name=XPR_29_III}
C {devices/lab_pin.sym} -1480 6670 0 0 {name=l5353 sig_type=std_logic lab=PL_29_III}
C {devices/lab_pin.sym} -1480 6690 0 0 {name=l5354 sig_type=std_logic lab=RG_29_III}
C {devices/lab_pin.sym} -1320 6670 0 0 {name=l5355 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 6690 0 0 {name=l5356 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 6900 0 0 {name=XLR_30_III}
C {devices/lab_pin.sym} -1780 6880 0 0 {name=l5357 sig_type=std_logic lab=RSEL_30}
C {devices/lab_pin.sym} -1780 6900 0 0 {name=l5358 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 6920 0 0 {name=l5359 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 6880 0 0 {name=l5360 sig_type=std_logic lab=RG_30_III}
C {devices/lab_pin.sym} -1620 6900 0 0 {name=l5361 sig_type=std_logic lab=WL_30_III}
C {devices/lab_pin.sym} -1620 6920 0 0 {name=l5362 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 6900 0 0 {name=XPR_30_III}
C {devices/lab_pin.sym} -1480 6890 0 0 {name=l5363 sig_type=std_logic lab=PL_30_III}
C {devices/lab_pin.sym} -1480 6910 0 0 {name=l5364 sig_type=std_logic lab=RG_30_III}
C {devices/lab_pin.sym} -1320 6890 0 0 {name=l5365 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 6910 0 0 {name=l5366 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -1700 7120 0 0 {name=XLR_31_III}
C {devices/lab_pin.sym} -1780 7100 0 0 {name=l5367 sig_type=std_logic lab=RSEL_31}
C {devices/lab_pin.sym} -1780 7120 0 0 {name=l5368 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -1780 7140 0 0 {name=l5369 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -1620 7100 0 0 {name=l5370 sig_type=std_logic lab=RG_31_III}
C {devices/lab_pin.sym} -1620 7120 0 0 {name=l5371 sig_type=std_logic lab=WL_31_III}
C {devices/lab_pin.sym} -1620 7140 0 0 {name=l5372 sig_type=std_logic lab=VDDH_III}
C {pg_n06.sym} -1400 7120 0 0 {name=XPR_31_III}
C {devices/lab_pin.sym} -1480 7110 0 0 {name=l5373 sig_type=std_logic lab=PL_31_III}
C {devices/lab_pin.sym} -1480 7130 0 0 {name=l5374 sig_type=std_logic lab=RG_31_III}
C {devices/lab_pin.sym} -1320 7110 0 0 {name=l5375 sig_type=std_logic lab=PLG_III}
C {devices/lab_pin.sym} -1320 7130 0 0 {name=l5376 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} -2000 100 0 0 {name=p5377 lab=RSEL_0}
C {devices/ipin.sym} -2000 130 0 0 {name=p5378 lab=RSEL_1}
C {devices/ipin.sym} -2000 160 0 0 {name=p5379 lab=RSEL_2}
C {devices/ipin.sym} -2000 190 0 0 {name=p5380 lab=RSEL_3}
C {devices/ipin.sym} -2000 220 0 0 {name=p5381 lab=RSEL_4}
C {devices/ipin.sym} -2000 250 0 0 {name=p5382 lab=RSEL_5}
C {devices/ipin.sym} -2000 280 0 0 {name=p5383 lab=RSEL_6}
C {devices/ipin.sym} -2000 310 0 0 {name=p5384 lab=RSEL_7}
C {devices/ipin.sym} -2000 340 0 0 {name=p5385 lab=RSEL_8}
C {devices/ipin.sym} -2000 370 0 0 {name=p5386 lab=RSEL_9}
C {devices/ipin.sym} -2000 400 0 0 {name=p5387 lab=RSEL_10}
C {devices/ipin.sym} -2000 430 0 0 {name=p5388 lab=RSEL_11}
C {devices/ipin.sym} -2000 460 0 0 {name=p5389 lab=RSEL_12}
C {devices/ipin.sym} -2000 490 0 0 {name=p5390 lab=RSEL_13}
C {devices/ipin.sym} -2000 520 0 0 {name=p5391 lab=RSEL_14}
C {devices/ipin.sym} -2000 550 0 0 {name=p5392 lab=RSEL_15}
C {devices/ipin.sym} -2000 580 0 0 {name=p5393 lab=RSEL_16}
C {devices/ipin.sym} -2000 610 0 0 {name=p5394 lab=RSEL_17}
C {devices/ipin.sym} -2000 640 0 0 {name=p5395 lab=RSEL_18}
C {devices/ipin.sym} -2000 670 0 0 {name=p5396 lab=RSEL_19}
C {devices/ipin.sym} -2000 700 0 0 {name=p5397 lab=RSEL_20}
C {devices/ipin.sym} -2000 730 0 0 {name=p5398 lab=RSEL_21}
C {devices/ipin.sym} -2000 760 0 0 {name=p5399 lab=RSEL_22}
C {devices/ipin.sym} -2000 790 0 0 {name=p5400 lab=RSEL_23}
C {devices/ipin.sym} -2000 820 0 0 {name=p5401 lab=RSEL_24}
C {devices/ipin.sym} -2000 850 0 0 {name=p5402 lab=RSEL_25}
C {devices/ipin.sym} -2000 880 0 0 {name=p5403 lab=RSEL_26}
C {devices/ipin.sym} -2000 910 0 0 {name=p5404 lab=RSEL_27}
C {devices/ipin.sym} -2000 940 0 0 {name=p5405 lab=RSEL_28}
C {devices/ipin.sym} -2000 970 0 0 {name=p5406 lab=RSEL_29}
C {devices/ipin.sym} -2000 1000 0 0 {name=p5407 lab=RSEL_30}
C {devices/ipin.sym} -2000 1030 0 0 {name=p5408 lab=RSEL_31}
C {devices/ipin.sym} -2000 1060 0 0 {name=p5409 lab=CSEL_0}
C {devices/ipin.sym} -2000 1090 0 0 {name=p5410 lab=CSEL_1}
C {devices/ipin.sym} -2000 1120 0 0 {name=p5411 lab=CSEL_2}
C {devices/ipin.sym} -2000 1150 0 0 {name=p5412 lab=CSEL_3}
C {devices/ipin.sym} -2000 1180 0 0 {name=p5413 lab=CSEL_4}
C {devices/ipin.sym} -2000 1210 0 0 {name=p5414 lab=CSEL_5}
C {devices/ipin.sym} -2000 1240 0 0 {name=p5415 lab=CSEL_6}
C {devices/ipin.sym} -2000 1270 0 0 {name=p5416 lab=CSEL_7}
C {devices/ipin.sym} -2000 1300 0 0 {name=p5417 lab=CSEL_8}
C {devices/ipin.sym} -2000 1330 0 0 {name=p5418 lab=CSEL_9}
C {devices/ipin.sym} -2000 1360 0 0 {name=p5419 lab=CSEL_10}
C {devices/ipin.sym} -2000 1390 0 0 {name=p5420 lab=CSEL_11}
C {devices/ipin.sym} -2000 1420 0 0 {name=p5421 lab=CSEL_12}
C {devices/ipin.sym} -2000 1450 0 0 {name=p5422 lab=CSEL_13}
C {devices/ipin.sym} -2000 1480 0 0 {name=p5423 lab=CSEL_14}
C {devices/ipin.sym} -2000 1510 0 0 {name=p5424 lab=CSEL_15}
C {devices/ipin.sym} -2000 1540 0 0 {name=p5425 lab=CSEL_16}
C {devices/ipin.sym} -2000 1570 0 0 {name=p5426 lab=CSEL_17}
C {devices/ipin.sym} -2000 1600 0 0 {name=p5427 lab=CSEL_18}
C {devices/ipin.sym} -2000 1630 0 0 {name=p5428 lab=CSEL_19}
C {devices/ipin.sym} -2000 1660 0 0 {name=p5429 lab=CSEL_20}
C {devices/ipin.sym} -2000 1690 0 0 {name=p5430 lab=CSEL_21}
C {devices/ipin.sym} -2000 1720 0 0 {name=p5431 lab=CSEL_22}
C {devices/ipin.sym} -2000 1750 0 0 {name=p5432 lab=CSEL_23}
C {devices/ipin.sym} -2000 1780 0 0 {name=p5433 lab=CSEL_24}
C {devices/ipin.sym} -2000 1810 0 0 {name=p5434 lab=CSEL_25}
C {devices/ipin.sym} -2000 1840 0 0 {name=p5435 lab=CSEL_26}
C {devices/ipin.sym} -2000 1870 0 0 {name=p5436 lab=CSEL_27}
C {devices/ipin.sym} -2000 1900 0 0 {name=p5437 lab=CSEL_28}
C {devices/ipin.sym} -2000 1930 0 0 {name=p5438 lab=CSEL_29}
C {devices/ipin.sym} -2000 1960 0 0 {name=p5439 lab=CSEL_30}
C {devices/ipin.sym} -2000 1990 0 0 {name=p5440 lab=CSEL_31}
C {devices/iopin.sym} -1800 100 0 0 {name=p5441 lab=BLG_I}
C {devices/iopin.sym} -1800 130 0 0 {name=p5442 lab=PLG_I}
C {devices/iopin.sym} -1800 160 0 0 {name=p5443 lab=BLG_II}
C {devices/iopin.sym} -1800 190 0 0 {name=p5444 lab=PLG_II}
C {devices/iopin.sym} -1800 220 0 0 {name=p5445 lab=BLG_III}
C {devices/iopin.sym} -1800 250 0 0 {name=p5446 lab=PLG_III}
C {devices/ipin.sym} -1800 280 0 0 {name=p5447 lab=VDDH_I}
C {devices/ipin.sym} -1800 310 0 0 {name=p5448 lab=VDDH_II}
C {devices/ipin.sym} -1800 340 0 0 {name=p5449 lab=VDDH_III}
C {devices/ipin.sym} -1800 370 0 0 {name=p5450 lab=VDDL}
C {devices/ipin.sym} -1800 400 0 0 {name=p5451 lab=VSS}
T {array_32x32: rows 0-31, cols 0-31 of the 32x32 array} -2000 0 0 0 0.8 0.8 {}
