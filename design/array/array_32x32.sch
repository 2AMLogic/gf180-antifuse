v {xschem version=3.4.7 file_version=1.2

* gf180-antifuse: array_32x32 - GENERATED by design/gen_array.py. Do not hand-edit;
* edit the generator and rerun design/regen-netlists.sh.
*
* Rows 0..31, columns 0..31 of the N=32 array (absolute coordinates),
* with the row/column local high-voltage addressing stage of
* spec/architecture.md 1.1 (level shifter -> HV pass-gate).
*
* Per-cell wcap/lcap/wacc/lacc and candidate type follow the region map in
* spec/split-axis-plan.md; design/check-array.py fails if they drift.
*
* Nets: BL_<c> column bit line; WL_<r>_<band> / PL_<r>_<band> word / plate line
* of one row segment; BLG_<band> / PLG_<band> per-band global bus the (out of
* scope) program / read legs attach to; CSEL_<c> / RSEL_<r> single-ended
* one-hot selects from the digital partition; VDDH_<band> level-shifter rail.
* Candidate 3's word line is active-low (PMOS access) and its cell VB is the
* band's VDDH rail (n-well tie at the most positive potential).
}
G {}
K {}
V {}
S {}
E {}
C {cell_candidate1.sym} 400 300 0 0 {name=Xc_0_0
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 270 0 0 {name=l1 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 330 0 0 {name=l2 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 480 270 0 0 {name=l3 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} 480 330 0 0 {name=l4 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 300 0 0 {name=Xc_0_1
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 270 0 0 {name=l5 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 330 0 0 {name=l6 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 880 270 0 0 {name=l7 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} 880 330 0 0 {name=l8 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 300 0 0 {name=Xc_0_2
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 270 0 0 {name=l9 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 330 0 0 {name=l10 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 1280 270 0 0 {name=l11 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} 1280 330 0 0 {name=l12 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 300 0 0 {name=Xc_0_3
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 270 0 0 {name=l13 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 330 0 0 {name=l14 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 1680 270 0 0 {name=l15 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} 1680 330 0 0 {name=l16 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 300 0 0 {name=Xc_0_4
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 270 0 0 {name=l17 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 330 0 0 {name=l18 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 2080 270 0 0 {name=l19 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} 2080 330 0 0 {name=l20 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 300 0 0 {name=Xc_0_5
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 270 0 0 {name=l21 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 330 0 0 {name=l22 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 2480 270 0 0 {name=l23 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} 2480 330 0 0 {name=l24 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 300 0 0 {name=Xc_0_6
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 270 0 0 {name=l25 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 330 0 0 {name=l26 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 2880 270 0 0 {name=l27 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} 2880 330 0 0 {name=l28 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 300 0 0 {name=Xc_0_7
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 270 0 0 {name=l29 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 330 0 0 {name=l30 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 3280 270 0 0 {name=l31 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} 3280 330 0 0 {name=l32 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 300 0 0 {name=Xc_0_8
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 270 0 0 {name=l33 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 330 0 0 {name=l34 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 3680 270 0 0 {name=l35 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} 3680 330 0 0 {name=l36 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 300 0 0 {name=Xc_0_9
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 270 0 0 {name=l37 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 330 0 0 {name=l38 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 4080 270 0 0 {name=l39 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} 4080 330 0 0 {name=l40 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 300 0 0 {name=Xc_0_10
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 270 0 0 {name=l41 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 330 0 0 {name=l42 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 4480 270 0 0 {name=l43 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} 4480 330 0 0 {name=l44 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 300 0 0 {name=Xc_0_11
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 270 0 0 {name=l45 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 330 0 0 {name=l46 sig_type=std_logic lab=WL_0_II}
C {devices/lab_pin.sym} 4880 270 0 0 {name=l47 sig_type=std_logic lab=PL_0_II}
C {devices/lab_pin.sym} 4880 330 0 0 {name=l48 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 300 0 0 {name=Xc_0_12
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 270 0 0 {name=l49 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 330 0 0 {name=l50 sig_type=std_logic lab=WL_0_II}
C {devices/lab_pin.sym} 5280 270 0 0 {name=l51 sig_type=std_logic lab=PL_0_II}
C {devices/lab_pin.sym} 5280 330 0 0 {name=l52 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 300 0 0 {name=Xc_0_13
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 270 0 0 {name=l53 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 330 0 0 {name=l54 sig_type=std_logic lab=WL_0_II}
C {devices/lab_pin.sym} 5680 270 0 0 {name=l55 sig_type=std_logic lab=PL_0_II}
C {devices/lab_pin.sym} 5680 330 0 0 {name=l56 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 300 0 0 {name=Xc_0_14
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 270 0 0 {name=l57 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 330 0 0 {name=l58 sig_type=std_logic lab=WL_0_II}
C {devices/lab_pin.sym} 6080 270 0 0 {name=l59 sig_type=std_logic lab=PL_0_II}
C {devices/lab_pin.sym} 6080 330 0 0 {name=l60 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 300 0 0 {name=Xc_0_15
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 270 0 0 {name=l61 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 330 0 0 {name=l62 sig_type=std_logic lab=WL_0_II}
C {devices/lab_pin.sym} 6480 270 0 0 {name=l63 sig_type=std_logic lab=PL_0_II}
C {devices/lab_pin.sym} 6480 330 0 0 {name=l64 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 300 0 0 {name=Xc_0_16
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 270 0 0 {name=l65 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 330 0 0 {name=l66 sig_type=std_logic lab=WL_0_II}
C {devices/lab_pin.sym} 6880 270 0 0 {name=l67 sig_type=std_logic lab=PL_0_II}
C {devices/lab_pin.sym} 6880 330 0 0 {name=l68 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 300 0 0 {name=Xc_0_17
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 270 0 0 {name=l69 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 330 0 0 {name=l70 sig_type=std_logic lab=WL_0_II}
C {devices/lab_pin.sym} 7280 270 0 0 {name=l71 sig_type=std_logic lab=PL_0_II}
C {devices/lab_pin.sym} 7280 330 0 0 {name=l72 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 300 0 0 {name=Xc_0_18
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 270 0 0 {name=l73 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 330 0 0 {name=l74 sig_type=std_logic lab=WL_0_II}
C {devices/lab_pin.sym} 7680 270 0 0 {name=l75 sig_type=std_logic lab=PL_0_II}
C {devices/lab_pin.sym} 7680 330 0 0 {name=l76 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 300 0 0 {name=Xc_0_19
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 270 0 0 {name=l77 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 330 0 0 {name=l78 sig_type=std_logic lab=WL_0_II}
C {devices/lab_pin.sym} 8080 270 0 0 {name=l79 sig_type=std_logic lab=PL_0_II}
C {devices/lab_pin.sym} 8080 330 0 0 {name=l80 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 300 0 0 {name=Xc_0_20
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 270 0 0 {name=l81 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 330 0 0 {name=l82 sig_type=std_logic lab=WL_0_II}
C {devices/lab_pin.sym} 8480 270 0 0 {name=l83 sig_type=std_logic lab=PL_0_II}
C {devices/lab_pin.sym} 8480 330 0 0 {name=l84 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 300 0 0 {name=Xc_0_21
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 270 0 0 {name=l85 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 330 0 0 {name=l86 sig_type=std_logic lab=WL_0_II}
C {devices/lab_pin.sym} 8880 270 0 0 {name=l87 sig_type=std_logic lab=PL_0_II}
C {devices/lab_pin.sym} 8880 330 0 0 {name=l88 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 300 0 0 {name=Xc_0_22
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 270 0 0 {name=l89 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 330 0 0 {name=l90 sig_type=std_logic lab=WL_0_III}
C {devices/lab_pin.sym} 9280 270 0 0 {name=l91 sig_type=std_logic lab=PL_0_III}
C {devices/lab_pin.sym} 9280 330 0 0 {name=l92 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 300 0 0 {name=Xc_0_23
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 270 0 0 {name=l93 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 330 0 0 {name=l94 sig_type=std_logic lab=WL_0_III}
C {devices/lab_pin.sym} 9680 270 0 0 {name=l95 sig_type=std_logic lab=PL_0_III}
C {devices/lab_pin.sym} 9680 330 0 0 {name=l96 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 300 0 0 {name=Xc_0_24
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 270 0 0 {name=l97 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 330 0 0 {name=l98 sig_type=std_logic lab=WL_0_III}
C {devices/lab_pin.sym} 10080 270 0 0 {name=l99 sig_type=std_logic lab=PL_0_III}
C {devices/lab_pin.sym} 10080 330 0 0 {name=l100 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 300 0 0 {name=Xc_0_25
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 270 0 0 {name=l101 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 330 0 0 {name=l102 sig_type=std_logic lab=WL_0_III}
C {devices/lab_pin.sym} 10480 270 0 0 {name=l103 sig_type=std_logic lab=PL_0_III}
C {devices/lab_pin.sym} 10480 330 0 0 {name=l104 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 300 0 0 {name=Xc_0_26
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 270 0 0 {name=l105 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 330 0 0 {name=l106 sig_type=std_logic lab=WL_0_III}
C {devices/lab_pin.sym} 10880 270 0 0 {name=l107 sig_type=std_logic lab=PL_0_III}
C {devices/lab_pin.sym} 10880 330 0 0 {name=l108 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 300 0 0 {name=Xc_0_27
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 270 0 0 {name=l109 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 330 0 0 {name=l110 sig_type=std_logic lab=WL_0_III}
C {devices/lab_pin.sym} 11280 270 0 0 {name=l111 sig_type=std_logic lab=PL_0_III}
C {devices/lab_pin.sym} 11280 330 0 0 {name=l112 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 300 0 0 {name=Xc_0_28
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 270 0 0 {name=l113 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 330 0 0 {name=l114 sig_type=std_logic lab=WL_0_III}
C {devices/lab_pin.sym} 11680 270 0 0 {name=l115 sig_type=std_logic lab=PL_0_III}
C {devices/lab_pin.sym} 11680 330 0 0 {name=l116 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 300 0 0 {name=Xc_0_29
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 270 0 0 {name=l117 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 330 0 0 {name=l118 sig_type=std_logic lab=WL_0_III}
C {devices/lab_pin.sym} 12080 270 0 0 {name=l119 sig_type=std_logic lab=PL_0_III}
C {devices/lab_pin.sym} 12080 330 0 0 {name=l120 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 300 0 0 {name=Xc_0_30
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 270 0 0 {name=l121 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 330 0 0 {name=l122 sig_type=std_logic lab=WL_0_III}
C {devices/lab_pin.sym} 12480 270 0 0 {name=l123 sig_type=std_logic lab=PL_0_III}
C {devices/lab_pin.sym} 12480 330 0 0 {name=l124 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 300 0 0 {name=Xc_0_31
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 270 0 0 {name=l125 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 330 0 0 {name=l126 sig_type=std_logic lab=WL_0_III}
C {devices/lab_pin.sym} 12880 270 0 0 {name=l127 sig_type=std_logic lab=PL_0_III}
C {devices/lab_pin.sym} 12880 330 0 0 {name=l128 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 520 0 0 {name=Xc_1_0
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 490 0 0 {name=l129 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 550 0 0 {name=l130 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 480 490 0 0 {name=l131 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} 480 550 0 0 {name=l132 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 520 0 0 {name=Xc_1_1
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 490 0 0 {name=l133 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 550 0 0 {name=l134 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 880 490 0 0 {name=l135 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} 880 550 0 0 {name=l136 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 520 0 0 {name=Xc_1_2
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 490 0 0 {name=l137 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 550 0 0 {name=l138 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 1280 490 0 0 {name=l139 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} 1280 550 0 0 {name=l140 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 520 0 0 {name=Xc_1_3
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 490 0 0 {name=l141 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 550 0 0 {name=l142 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 1680 490 0 0 {name=l143 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} 1680 550 0 0 {name=l144 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 520 0 0 {name=Xc_1_4
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 490 0 0 {name=l145 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 550 0 0 {name=l146 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 2080 490 0 0 {name=l147 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} 2080 550 0 0 {name=l148 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 520 0 0 {name=Xc_1_5
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 490 0 0 {name=l149 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 550 0 0 {name=l150 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 2480 490 0 0 {name=l151 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} 2480 550 0 0 {name=l152 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 520 0 0 {name=Xc_1_6
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 490 0 0 {name=l153 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 550 0 0 {name=l154 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 2880 490 0 0 {name=l155 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} 2880 550 0 0 {name=l156 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 520 0 0 {name=Xc_1_7
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 490 0 0 {name=l157 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 550 0 0 {name=l158 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 3280 490 0 0 {name=l159 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} 3280 550 0 0 {name=l160 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 520 0 0 {name=Xc_1_8
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 490 0 0 {name=l161 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 550 0 0 {name=l162 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 3680 490 0 0 {name=l163 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} 3680 550 0 0 {name=l164 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 520 0 0 {name=Xc_1_9
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 490 0 0 {name=l165 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 550 0 0 {name=l166 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 4080 490 0 0 {name=l167 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} 4080 550 0 0 {name=l168 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 520 0 0 {name=Xc_1_10
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 490 0 0 {name=l169 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 550 0 0 {name=l170 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 4480 490 0 0 {name=l171 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} 4480 550 0 0 {name=l172 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 520 0 0 {name=Xc_1_11
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 490 0 0 {name=l173 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 550 0 0 {name=l174 sig_type=std_logic lab=WL_1_II}
C {devices/lab_pin.sym} 4880 490 0 0 {name=l175 sig_type=std_logic lab=PL_1_II}
C {devices/lab_pin.sym} 4880 550 0 0 {name=l176 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 520 0 0 {name=Xc_1_12
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 490 0 0 {name=l177 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 550 0 0 {name=l178 sig_type=std_logic lab=WL_1_II}
C {devices/lab_pin.sym} 5280 490 0 0 {name=l179 sig_type=std_logic lab=PL_1_II}
C {devices/lab_pin.sym} 5280 550 0 0 {name=l180 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 520 0 0 {name=Xc_1_13
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 490 0 0 {name=l181 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 550 0 0 {name=l182 sig_type=std_logic lab=WL_1_II}
C {devices/lab_pin.sym} 5680 490 0 0 {name=l183 sig_type=std_logic lab=PL_1_II}
C {devices/lab_pin.sym} 5680 550 0 0 {name=l184 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 520 0 0 {name=Xc_1_14
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 490 0 0 {name=l185 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 550 0 0 {name=l186 sig_type=std_logic lab=WL_1_II}
C {devices/lab_pin.sym} 6080 490 0 0 {name=l187 sig_type=std_logic lab=PL_1_II}
C {devices/lab_pin.sym} 6080 550 0 0 {name=l188 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 520 0 0 {name=Xc_1_15
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 490 0 0 {name=l189 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 550 0 0 {name=l190 sig_type=std_logic lab=WL_1_II}
C {devices/lab_pin.sym} 6480 490 0 0 {name=l191 sig_type=std_logic lab=PL_1_II}
C {devices/lab_pin.sym} 6480 550 0 0 {name=l192 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 520 0 0 {name=Xc_1_16
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 490 0 0 {name=l193 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 550 0 0 {name=l194 sig_type=std_logic lab=WL_1_II}
C {devices/lab_pin.sym} 6880 490 0 0 {name=l195 sig_type=std_logic lab=PL_1_II}
C {devices/lab_pin.sym} 6880 550 0 0 {name=l196 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 520 0 0 {name=Xc_1_17
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 490 0 0 {name=l197 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 550 0 0 {name=l198 sig_type=std_logic lab=WL_1_II}
C {devices/lab_pin.sym} 7280 490 0 0 {name=l199 sig_type=std_logic lab=PL_1_II}
C {devices/lab_pin.sym} 7280 550 0 0 {name=l200 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 520 0 0 {name=Xc_1_18
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 490 0 0 {name=l201 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 550 0 0 {name=l202 sig_type=std_logic lab=WL_1_II}
C {devices/lab_pin.sym} 7680 490 0 0 {name=l203 sig_type=std_logic lab=PL_1_II}
C {devices/lab_pin.sym} 7680 550 0 0 {name=l204 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 520 0 0 {name=Xc_1_19
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 490 0 0 {name=l205 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 550 0 0 {name=l206 sig_type=std_logic lab=WL_1_II}
C {devices/lab_pin.sym} 8080 490 0 0 {name=l207 sig_type=std_logic lab=PL_1_II}
C {devices/lab_pin.sym} 8080 550 0 0 {name=l208 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 520 0 0 {name=Xc_1_20
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 490 0 0 {name=l209 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 550 0 0 {name=l210 sig_type=std_logic lab=WL_1_II}
C {devices/lab_pin.sym} 8480 490 0 0 {name=l211 sig_type=std_logic lab=PL_1_II}
C {devices/lab_pin.sym} 8480 550 0 0 {name=l212 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 520 0 0 {name=Xc_1_21
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 490 0 0 {name=l213 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 550 0 0 {name=l214 sig_type=std_logic lab=WL_1_II}
C {devices/lab_pin.sym} 8880 490 0 0 {name=l215 sig_type=std_logic lab=PL_1_II}
C {devices/lab_pin.sym} 8880 550 0 0 {name=l216 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 520 0 0 {name=Xc_1_22
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 490 0 0 {name=l217 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 550 0 0 {name=l218 sig_type=std_logic lab=WL_1_III}
C {devices/lab_pin.sym} 9280 490 0 0 {name=l219 sig_type=std_logic lab=PL_1_III}
C {devices/lab_pin.sym} 9280 550 0 0 {name=l220 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 520 0 0 {name=Xc_1_23
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 490 0 0 {name=l221 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 550 0 0 {name=l222 sig_type=std_logic lab=WL_1_III}
C {devices/lab_pin.sym} 9680 490 0 0 {name=l223 sig_type=std_logic lab=PL_1_III}
C {devices/lab_pin.sym} 9680 550 0 0 {name=l224 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 520 0 0 {name=Xc_1_24
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 490 0 0 {name=l225 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 550 0 0 {name=l226 sig_type=std_logic lab=WL_1_III}
C {devices/lab_pin.sym} 10080 490 0 0 {name=l227 sig_type=std_logic lab=PL_1_III}
C {devices/lab_pin.sym} 10080 550 0 0 {name=l228 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 520 0 0 {name=Xc_1_25
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 490 0 0 {name=l229 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 550 0 0 {name=l230 sig_type=std_logic lab=WL_1_III}
C {devices/lab_pin.sym} 10480 490 0 0 {name=l231 sig_type=std_logic lab=PL_1_III}
C {devices/lab_pin.sym} 10480 550 0 0 {name=l232 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 520 0 0 {name=Xc_1_26
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 490 0 0 {name=l233 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 550 0 0 {name=l234 sig_type=std_logic lab=WL_1_III}
C {devices/lab_pin.sym} 10880 490 0 0 {name=l235 sig_type=std_logic lab=PL_1_III}
C {devices/lab_pin.sym} 10880 550 0 0 {name=l236 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 520 0 0 {name=Xc_1_27
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 490 0 0 {name=l237 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 550 0 0 {name=l238 sig_type=std_logic lab=WL_1_III}
C {devices/lab_pin.sym} 11280 490 0 0 {name=l239 sig_type=std_logic lab=PL_1_III}
C {devices/lab_pin.sym} 11280 550 0 0 {name=l240 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 520 0 0 {name=Xc_1_28
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 490 0 0 {name=l241 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 550 0 0 {name=l242 sig_type=std_logic lab=WL_1_III}
C {devices/lab_pin.sym} 11680 490 0 0 {name=l243 sig_type=std_logic lab=PL_1_III}
C {devices/lab_pin.sym} 11680 550 0 0 {name=l244 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 520 0 0 {name=Xc_1_29
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 490 0 0 {name=l245 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 550 0 0 {name=l246 sig_type=std_logic lab=WL_1_III}
C {devices/lab_pin.sym} 12080 490 0 0 {name=l247 sig_type=std_logic lab=PL_1_III}
C {devices/lab_pin.sym} 12080 550 0 0 {name=l248 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 520 0 0 {name=Xc_1_30
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 490 0 0 {name=l249 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 550 0 0 {name=l250 sig_type=std_logic lab=WL_1_III}
C {devices/lab_pin.sym} 12480 490 0 0 {name=l251 sig_type=std_logic lab=PL_1_III}
C {devices/lab_pin.sym} 12480 550 0 0 {name=l252 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 520 0 0 {name=Xc_1_31
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 490 0 0 {name=l253 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 550 0 0 {name=l254 sig_type=std_logic lab=WL_1_III}
C {devices/lab_pin.sym} 12880 490 0 0 {name=l255 sig_type=std_logic lab=PL_1_III}
C {devices/lab_pin.sym} 12880 550 0 0 {name=l256 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 740 0 0 {name=Xc_2_0
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 710 0 0 {name=l257 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 770 0 0 {name=l258 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 480 710 0 0 {name=l259 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} 480 770 0 0 {name=l260 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 740 0 0 {name=Xc_2_1
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 710 0 0 {name=l261 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 770 0 0 {name=l262 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 880 710 0 0 {name=l263 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} 880 770 0 0 {name=l264 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 740 0 0 {name=Xc_2_2
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 710 0 0 {name=l265 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 770 0 0 {name=l266 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 1280 710 0 0 {name=l267 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} 1280 770 0 0 {name=l268 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 740 0 0 {name=Xc_2_3
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 710 0 0 {name=l269 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 770 0 0 {name=l270 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 1680 710 0 0 {name=l271 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} 1680 770 0 0 {name=l272 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 740 0 0 {name=Xc_2_4
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 710 0 0 {name=l273 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 770 0 0 {name=l274 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 2080 710 0 0 {name=l275 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} 2080 770 0 0 {name=l276 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 740 0 0 {name=Xc_2_5
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 710 0 0 {name=l277 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 770 0 0 {name=l278 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 2480 710 0 0 {name=l279 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} 2480 770 0 0 {name=l280 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 740 0 0 {name=Xc_2_6
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 710 0 0 {name=l281 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 770 0 0 {name=l282 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 2880 710 0 0 {name=l283 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} 2880 770 0 0 {name=l284 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 740 0 0 {name=Xc_2_7
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 710 0 0 {name=l285 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 770 0 0 {name=l286 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 3280 710 0 0 {name=l287 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} 3280 770 0 0 {name=l288 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 740 0 0 {name=Xc_2_8
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 710 0 0 {name=l289 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 770 0 0 {name=l290 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 3680 710 0 0 {name=l291 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} 3680 770 0 0 {name=l292 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 740 0 0 {name=Xc_2_9
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 710 0 0 {name=l293 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 770 0 0 {name=l294 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 4080 710 0 0 {name=l295 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} 4080 770 0 0 {name=l296 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 740 0 0 {name=Xc_2_10
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 710 0 0 {name=l297 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 770 0 0 {name=l298 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 4480 710 0 0 {name=l299 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} 4480 770 0 0 {name=l300 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 740 0 0 {name=Xc_2_11
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 710 0 0 {name=l301 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 770 0 0 {name=l302 sig_type=std_logic lab=WL_2_II}
C {devices/lab_pin.sym} 4880 710 0 0 {name=l303 sig_type=std_logic lab=PL_2_II}
C {devices/lab_pin.sym} 4880 770 0 0 {name=l304 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 740 0 0 {name=Xc_2_12
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 710 0 0 {name=l305 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 770 0 0 {name=l306 sig_type=std_logic lab=WL_2_II}
C {devices/lab_pin.sym} 5280 710 0 0 {name=l307 sig_type=std_logic lab=PL_2_II}
C {devices/lab_pin.sym} 5280 770 0 0 {name=l308 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 740 0 0 {name=Xc_2_13
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 710 0 0 {name=l309 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 770 0 0 {name=l310 sig_type=std_logic lab=WL_2_II}
C {devices/lab_pin.sym} 5680 710 0 0 {name=l311 sig_type=std_logic lab=PL_2_II}
C {devices/lab_pin.sym} 5680 770 0 0 {name=l312 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 740 0 0 {name=Xc_2_14
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 710 0 0 {name=l313 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 770 0 0 {name=l314 sig_type=std_logic lab=WL_2_II}
C {devices/lab_pin.sym} 6080 710 0 0 {name=l315 sig_type=std_logic lab=PL_2_II}
C {devices/lab_pin.sym} 6080 770 0 0 {name=l316 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 740 0 0 {name=Xc_2_15
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 710 0 0 {name=l317 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 770 0 0 {name=l318 sig_type=std_logic lab=WL_2_II}
C {devices/lab_pin.sym} 6480 710 0 0 {name=l319 sig_type=std_logic lab=PL_2_II}
C {devices/lab_pin.sym} 6480 770 0 0 {name=l320 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 740 0 0 {name=Xc_2_16
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 710 0 0 {name=l321 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 770 0 0 {name=l322 sig_type=std_logic lab=WL_2_II}
C {devices/lab_pin.sym} 6880 710 0 0 {name=l323 sig_type=std_logic lab=PL_2_II}
C {devices/lab_pin.sym} 6880 770 0 0 {name=l324 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 740 0 0 {name=Xc_2_17
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 710 0 0 {name=l325 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 770 0 0 {name=l326 sig_type=std_logic lab=WL_2_II}
C {devices/lab_pin.sym} 7280 710 0 0 {name=l327 sig_type=std_logic lab=PL_2_II}
C {devices/lab_pin.sym} 7280 770 0 0 {name=l328 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 740 0 0 {name=Xc_2_18
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 710 0 0 {name=l329 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 770 0 0 {name=l330 sig_type=std_logic lab=WL_2_II}
C {devices/lab_pin.sym} 7680 710 0 0 {name=l331 sig_type=std_logic lab=PL_2_II}
C {devices/lab_pin.sym} 7680 770 0 0 {name=l332 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 740 0 0 {name=Xc_2_19
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 710 0 0 {name=l333 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 770 0 0 {name=l334 sig_type=std_logic lab=WL_2_II}
C {devices/lab_pin.sym} 8080 710 0 0 {name=l335 sig_type=std_logic lab=PL_2_II}
C {devices/lab_pin.sym} 8080 770 0 0 {name=l336 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 740 0 0 {name=Xc_2_20
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 710 0 0 {name=l337 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 770 0 0 {name=l338 sig_type=std_logic lab=WL_2_II}
C {devices/lab_pin.sym} 8480 710 0 0 {name=l339 sig_type=std_logic lab=PL_2_II}
C {devices/lab_pin.sym} 8480 770 0 0 {name=l340 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 740 0 0 {name=Xc_2_21
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 710 0 0 {name=l341 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 770 0 0 {name=l342 sig_type=std_logic lab=WL_2_II}
C {devices/lab_pin.sym} 8880 710 0 0 {name=l343 sig_type=std_logic lab=PL_2_II}
C {devices/lab_pin.sym} 8880 770 0 0 {name=l344 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 740 0 0 {name=Xc_2_22
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 710 0 0 {name=l345 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 770 0 0 {name=l346 sig_type=std_logic lab=WL_2_III}
C {devices/lab_pin.sym} 9280 710 0 0 {name=l347 sig_type=std_logic lab=PL_2_III}
C {devices/lab_pin.sym} 9280 770 0 0 {name=l348 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 740 0 0 {name=Xc_2_23
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 710 0 0 {name=l349 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 770 0 0 {name=l350 sig_type=std_logic lab=WL_2_III}
C {devices/lab_pin.sym} 9680 710 0 0 {name=l351 sig_type=std_logic lab=PL_2_III}
C {devices/lab_pin.sym} 9680 770 0 0 {name=l352 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 740 0 0 {name=Xc_2_24
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 710 0 0 {name=l353 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 770 0 0 {name=l354 sig_type=std_logic lab=WL_2_III}
C {devices/lab_pin.sym} 10080 710 0 0 {name=l355 sig_type=std_logic lab=PL_2_III}
C {devices/lab_pin.sym} 10080 770 0 0 {name=l356 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 740 0 0 {name=Xc_2_25
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 710 0 0 {name=l357 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 770 0 0 {name=l358 sig_type=std_logic lab=WL_2_III}
C {devices/lab_pin.sym} 10480 710 0 0 {name=l359 sig_type=std_logic lab=PL_2_III}
C {devices/lab_pin.sym} 10480 770 0 0 {name=l360 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 740 0 0 {name=Xc_2_26
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 710 0 0 {name=l361 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 770 0 0 {name=l362 sig_type=std_logic lab=WL_2_III}
C {devices/lab_pin.sym} 10880 710 0 0 {name=l363 sig_type=std_logic lab=PL_2_III}
C {devices/lab_pin.sym} 10880 770 0 0 {name=l364 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 740 0 0 {name=Xc_2_27
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 710 0 0 {name=l365 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 770 0 0 {name=l366 sig_type=std_logic lab=WL_2_III}
C {devices/lab_pin.sym} 11280 710 0 0 {name=l367 sig_type=std_logic lab=PL_2_III}
C {devices/lab_pin.sym} 11280 770 0 0 {name=l368 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 740 0 0 {name=Xc_2_28
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 710 0 0 {name=l369 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 770 0 0 {name=l370 sig_type=std_logic lab=WL_2_III}
C {devices/lab_pin.sym} 11680 710 0 0 {name=l371 sig_type=std_logic lab=PL_2_III}
C {devices/lab_pin.sym} 11680 770 0 0 {name=l372 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 740 0 0 {name=Xc_2_29
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 710 0 0 {name=l373 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 770 0 0 {name=l374 sig_type=std_logic lab=WL_2_III}
C {devices/lab_pin.sym} 12080 710 0 0 {name=l375 sig_type=std_logic lab=PL_2_III}
C {devices/lab_pin.sym} 12080 770 0 0 {name=l376 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 740 0 0 {name=Xc_2_30
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 710 0 0 {name=l377 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 770 0 0 {name=l378 sig_type=std_logic lab=WL_2_III}
C {devices/lab_pin.sym} 12480 710 0 0 {name=l379 sig_type=std_logic lab=PL_2_III}
C {devices/lab_pin.sym} 12480 770 0 0 {name=l380 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 740 0 0 {name=Xc_2_31
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 710 0 0 {name=l381 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 770 0 0 {name=l382 sig_type=std_logic lab=WL_2_III}
C {devices/lab_pin.sym} 12880 710 0 0 {name=l383 sig_type=std_logic lab=PL_2_III}
C {devices/lab_pin.sym} 12880 770 0 0 {name=l384 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 960 0 0 {name=Xc_3_0
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 930 0 0 {name=l385 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 990 0 0 {name=l386 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 480 930 0 0 {name=l387 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} 480 990 0 0 {name=l388 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 960 0 0 {name=Xc_3_1
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 930 0 0 {name=l389 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 990 0 0 {name=l390 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 880 930 0 0 {name=l391 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} 880 990 0 0 {name=l392 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 960 0 0 {name=Xc_3_2
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 930 0 0 {name=l393 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 990 0 0 {name=l394 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 1280 930 0 0 {name=l395 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} 1280 990 0 0 {name=l396 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 960 0 0 {name=Xc_3_3
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 930 0 0 {name=l397 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 990 0 0 {name=l398 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 1680 930 0 0 {name=l399 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} 1680 990 0 0 {name=l400 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 960 0 0 {name=Xc_3_4
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 930 0 0 {name=l401 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 990 0 0 {name=l402 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 2080 930 0 0 {name=l403 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} 2080 990 0 0 {name=l404 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 960 0 0 {name=Xc_3_5
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 930 0 0 {name=l405 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 990 0 0 {name=l406 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 2480 930 0 0 {name=l407 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} 2480 990 0 0 {name=l408 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 960 0 0 {name=Xc_3_6
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 930 0 0 {name=l409 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 990 0 0 {name=l410 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 2880 930 0 0 {name=l411 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} 2880 990 0 0 {name=l412 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 960 0 0 {name=Xc_3_7
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 930 0 0 {name=l413 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 990 0 0 {name=l414 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 3280 930 0 0 {name=l415 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} 3280 990 0 0 {name=l416 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 960 0 0 {name=Xc_3_8
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 930 0 0 {name=l417 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 990 0 0 {name=l418 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 3680 930 0 0 {name=l419 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} 3680 990 0 0 {name=l420 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 960 0 0 {name=Xc_3_9
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 930 0 0 {name=l421 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 990 0 0 {name=l422 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 4080 930 0 0 {name=l423 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} 4080 990 0 0 {name=l424 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 960 0 0 {name=Xc_3_10
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 930 0 0 {name=l425 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 990 0 0 {name=l426 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 4480 930 0 0 {name=l427 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} 4480 990 0 0 {name=l428 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 960 0 0 {name=Xc_3_11
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 930 0 0 {name=l429 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 990 0 0 {name=l430 sig_type=std_logic lab=WL_3_II}
C {devices/lab_pin.sym} 4880 930 0 0 {name=l431 sig_type=std_logic lab=PL_3_II}
C {devices/lab_pin.sym} 4880 990 0 0 {name=l432 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 960 0 0 {name=Xc_3_12
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 930 0 0 {name=l433 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 990 0 0 {name=l434 sig_type=std_logic lab=WL_3_II}
C {devices/lab_pin.sym} 5280 930 0 0 {name=l435 sig_type=std_logic lab=PL_3_II}
C {devices/lab_pin.sym} 5280 990 0 0 {name=l436 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 960 0 0 {name=Xc_3_13
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 930 0 0 {name=l437 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 990 0 0 {name=l438 sig_type=std_logic lab=WL_3_II}
C {devices/lab_pin.sym} 5680 930 0 0 {name=l439 sig_type=std_logic lab=PL_3_II}
C {devices/lab_pin.sym} 5680 990 0 0 {name=l440 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 960 0 0 {name=Xc_3_14
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 930 0 0 {name=l441 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 990 0 0 {name=l442 sig_type=std_logic lab=WL_3_II}
C {devices/lab_pin.sym} 6080 930 0 0 {name=l443 sig_type=std_logic lab=PL_3_II}
C {devices/lab_pin.sym} 6080 990 0 0 {name=l444 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 960 0 0 {name=Xc_3_15
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 930 0 0 {name=l445 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 990 0 0 {name=l446 sig_type=std_logic lab=WL_3_II}
C {devices/lab_pin.sym} 6480 930 0 0 {name=l447 sig_type=std_logic lab=PL_3_II}
C {devices/lab_pin.sym} 6480 990 0 0 {name=l448 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 960 0 0 {name=Xc_3_16
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 930 0 0 {name=l449 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 990 0 0 {name=l450 sig_type=std_logic lab=WL_3_II}
C {devices/lab_pin.sym} 6880 930 0 0 {name=l451 sig_type=std_logic lab=PL_3_II}
C {devices/lab_pin.sym} 6880 990 0 0 {name=l452 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 960 0 0 {name=Xc_3_17
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 930 0 0 {name=l453 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 990 0 0 {name=l454 sig_type=std_logic lab=WL_3_II}
C {devices/lab_pin.sym} 7280 930 0 0 {name=l455 sig_type=std_logic lab=PL_3_II}
C {devices/lab_pin.sym} 7280 990 0 0 {name=l456 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 960 0 0 {name=Xc_3_18
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 930 0 0 {name=l457 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 990 0 0 {name=l458 sig_type=std_logic lab=WL_3_II}
C {devices/lab_pin.sym} 7680 930 0 0 {name=l459 sig_type=std_logic lab=PL_3_II}
C {devices/lab_pin.sym} 7680 990 0 0 {name=l460 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 960 0 0 {name=Xc_3_19
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 930 0 0 {name=l461 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 990 0 0 {name=l462 sig_type=std_logic lab=WL_3_II}
C {devices/lab_pin.sym} 8080 930 0 0 {name=l463 sig_type=std_logic lab=PL_3_II}
C {devices/lab_pin.sym} 8080 990 0 0 {name=l464 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 960 0 0 {name=Xc_3_20
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 930 0 0 {name=l465 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 990 0 0 {name=l466 sig_type=std_logic lab=WL_3_II}
C {devices/lab_pin.sym} 8480 930 0 0 {name=l467 sig_type=std_logic lab=PL_3_II}
C {devices/lab_pin.sym} 8480 990 0 0 {name=l468 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 960 0 0 {name=Xc_3_21
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 930 0 0 {name=l469 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 990 0 0 {name=l470 sig_type=std_logic lab=WL_3_II}
C {devices/lab_pin.sym} 8880 930 0 0 {name=l471 sig_type=std_logic lab=PL_3_II}
C {devices/lab_pin.sym} 8880 990 0 0 {name=l472 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 960 0 0 {name=Xc_3_22
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 930 0 0 {name=l473 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 990 0 0 {name=l474 sig_type=std_logic lab=WL_3_III}
C {devices/lab_pin.sym} 9280 930 0 0 {name=l475 sig_type=std_logic lab=PL_3_III}
C {devices/lab_pin.sym} 9280 990 0 0 {name=l476 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 960 0 0 {name=Xc_3_23
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 930 0 0 {name=l477 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 990 0 0 {name=l478 sig_type=std_logic lab=WL_3_III}
C {devices/lab_pin.sym} 9680 930 0 0 {name=l479 sig_type=std_logic lab=PL_3_III}
C {devices/lab_pin.sym} 9680 990 0 0 {name=l480 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 960 0 0 {name=Xc_3_24
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 930 0 0 {name=l481 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 990 0 0 {name=l482 sig_type=std_logic lab=WL_3_III}
C {devices/lab_pin.sym} 10080 930 0 0 {name=l483 sig_type=std_logic lab=PL_3_III}
C {devices/lab_pin.sym} 10080 990 0 0 {name=l484 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 960 0 0 {name=Xc_3_25
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 930 0 0 {name=l485 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 990 0 0 {name=l486 sig_type=std_logic lab=WL_3_III}
C {devices/lab_pin.sym} 10480 930 0 0 {name=l487 sig_type=std_logic lab=PL_3_III}
C {devices/lab_pin.sym} 10480 990 0 0 {name=l488 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 960 0 0 {name=Xc_3_26
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 930 0 0 {name=l489 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 990 0 0 {name=l490 sig_type=std_logic lab=WL_3_III}
C {devices/lab_pin.sym} 10880 930 0 0 {name=l491 sig_type=std_logic lab=PL_3_III}
C {devices/lab_pin.sym} 10880 990 0 0 {name=l492 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 960 0 0 {name=Xc_3_27
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 930 0 0 {name=l493 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 990 0 0 {name=l494 sig_type=std_logic lab=WL_3_III}
C {devices/lab_pin.sym} 11280 930 0 0 {name=l495 sig_type=std_logic lab=PL_3_III}
C {devices/lab_pin.sym} 11280 990 0 0 {name=l496 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 960 0 0 {name=Xc_3_28
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 930 0 0 {name=l497 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 990 0 0 {name=l498 sig_type=std_logic lab=WL_3_III}
C {devices/lab_pin.sym} 11680 930 0 0 {name=l499 sig_type=std_logic lab=PL_3_III}
C {devices/lab_pin.sym} 11680 990 0 0 {name=l500 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 960 0 0 {name=Xc_3_29
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 930 0 0 {name=l501 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 990 0 0 {name=l502 sig_type=std_logic lab=WL_3_III}
C {devices/lab_pin.sym} 12080 930 0 0 {name=l503 sig_type=std_logic lab=PL_3_III}
C {devices/lab_pin.sym} 12080 990 0 0 {name=l504 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 960 0 0 {name=Xc_3_30
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 930 0 0 {name=l505 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 990 0 0 {name=l506 sig_type=std_logic lab=WL_3_III}
C {devices/lab_pin.sym} 12480 930 0 0 {name=l507 sig_type=std_logic lab=PL_3_III}
C {devices/lab_pin.sym} 12480 990 0 0 {name=l508 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 960 0 0 {name=Xc_3_31
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 930 0 0 {name=l509 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 990 0 0 {name=l510 sig_type=std_logic lab=WL_3_III}
C {devices/lab_pin.sym} 12880 930 0 0 {name=l511 sig_type=std_logic lab=PL_3_III}
C {devices/lab_pin.sym} 12880 990 0 0 {name=l512 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 1180 0 0 {name=Xc_4_0
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 1150 0 0 {name=l513 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 1210 0 0 {name=l514 sig_type=std_logic lab=WL_4_I}
C {devices/lab_pin.sym} 480 1150 0 0 {name=l515 sig_type=std_logic lab=PL_4_I}
C {devices/lab_pin.sym} 480 1210 0 0 {name=l516 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 1180 0 0 {name=Xc_4_1
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 1150 0 0 {name=l517 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 1210 0 0 {name=l518 sig_type=std_logic lab=WL_4_I}
C {devices/lab_pin.sym} 880 1150 0 0 {name=l519 sig_type=std_logic lab=PL_4_I}
C {devices/lab_pin.sym} 880 1210 0 0 {name=l520 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 1180 0 0 {name=Xc_4_2
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 1150 0 0 {name=l521 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 1210 0 0 {name=l522 sig_type=std_logic lab=WL_4_I}
C {devices/lab_pin.sym} 1280 1150 0 0 {name=l523 sig_type=std_logic lab=PL_4_I}
C {devices/lab_pin.sym} 1280 1210 0 0 {name=l524 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 1180 0 0 {name=Xc_4_3
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 1150 0 0 {name=l525 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 1210 0 0 {name=l526 sig_type=std_logic lab=WL_4_I}
C {devices/lab_pin.sym} 1680 1150 0 0 {name=l527 sig_type=std_logic lab=PL_4_I}
C {devices/lab_pin.sym} 1680 1210 0 0 {name=l528 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 1180 0 0 {name=Xc_4_4
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 1150 0 0 {name=l529 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 1210 0 0 {name=l530 sig_type=std_logic lab=WL_4_I}
C {devices/lab_pin.sym} 2080 1150 0 0 {name=l531 sig_type=std_logic lab=PL_4_I}
C {devices/lab_pin.sym} 2080 1210 0 0 {name=l532 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 1180 0 0 {name=Xc_4_5
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 1150 0 0 {name=l533 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 1210 0 0 {name=l534 sig_type=std_logic lab=WL_4_I}
C {devices/lab_pin.sym} 2480 1150 0 0 {name=l535 sig_type=std_logic lab=PL_4_I}
C {devices/lab_pin.sym} 2480 1210 0 0 {name=l536 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 1180 0 0 {name=Xc_4_6
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 1150 0 0 {name=l537 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 1210 0 0 {name=l538 sig_type=std_logic lab=WL_4_I}
C {devices/lab_pin.sym} 2880 1150 0 0 {name=l539 sig_type=std_logic lab=PL_4_I}
C {devices/lab_pin.sym} 2880 1210 0 0 {name=l540 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 1180 0 0 {name=Xc_4_7
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 1150 0 0 {name=l541 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 1210 0 0 {name=l542 sig_type=std_logic lab=WL_4_I}
C {devices/lab_pin.sym} 3280 1150 0 0 {name=l543 sig_type=std_logic lab=PL_4_I}
C {devices/lab_pin.sym} 3280 1210 0 0 {name=l544 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 1180 0 0 {name=Xc_4_8
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 1150 0 0 {name=l545 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 1210 0 0 {name=l546 sig_type=std_logic lab=WL_4_I}
C {devices/lab_pin.sym} 3680 1150 0 0 {name=l547 sig_type=std_logic lab=PL_4_I}
C {devices/lab_pin.sym} 3680 1210 0 0 {name=l548 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 1180 0 0 {name=Xc_4_9
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 1150 0 0 {name=l549 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 1210 0 0 {name=l550 sig_type=std_logic lab=WL_4_I}
C {devices/lab_pin.sym} 4080 1150 0 0 {name=l551 sig_type=std_logic lab=PL_4_I}
C {devices/lab_pin.sym} 4080 1210 0 0 {name=l552 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 1180 0 0 {name=Xc_4_10
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 1150 0 0 {name=l553 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 1210 0 0 {name=l554 sig_type=std_logic lab=WL_4_I}
C {devices/lab_pin.sym} 4480 1150 0 0 {name=l555 sig_type=std_logic lab=PL_4_I}
C {devices/lab_pin.sym} 4480 1210 0 0 {name=l556 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 1180 0 0 {name=Xc_4_11
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 1150 0 0 {name=l557 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 1210 0 0 {name=l558 sig_type=std_logic lab=WL_4_II}
C {devices/lab_pin.sym} 4880 1150 0 0 {name=l559 sig_type=std_logic lab=PL_4_II}
C {devices/lab_pin.sym} 4880 1210 0 0 {name=l560 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 1180 0 0 {name=Xc_4_12
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 1150 0 0 {name=l561 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 1210 0 0 {name=l562 sig_type=std_logic lab=WL_4_II}
C {devices/lab_pin.sym} 5280 1150 0 0 {name=l563 sig_type=std_logic lab=PL_4_II}
C {devices/lab_pin.sym} 5280 1210 0 0 {name=l564 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 1180 0 0 {name=Xc_4_13
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 1150 0 0 {name=l565 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 1210 0 0 {name=l566 sig_type=std_logic lab=WL_4_II}
C {devices/lab_pin.sym} 5680 1150 0 0 {name=l567 sig_type=std_logic lab=PL_4_II}
C {devices/lab_pin.sym} 5680 1210 0 0 {name=l568 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 1180 0 0 {name=Xc_4_14
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 1150 0 0 {name=l569 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 1210 0 0 {name=l570 sig_type=std_logic lab=WL_4_II}
C {devices/lab_pin.sym} 6080 1150 0 0 {name=l571 sig_type=std_logic lab=PL_4_II}
C {devices/lab_pin.sym} 6080 1210 0 0 {name=l572 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 1180 0 0 {name=Xc_4_15
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 1150 0 0 {name=l573 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 1210 0 0 {name=l574 sig_type=std_logic lab=WL_4_II}
C {devices/lab_pin.sym} 6480 1150 0 0 {name=l575 sig_type=std_logic lab=PL_4_II}
C {devices/lab_pin.sym} 6480 1210 0 0 {name=l576 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 1180 0 0 {name=Xc_4_16
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 1150 0 0 {name=l577 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 1210 0 0 {name=l578 sig_type=std_logic lab=WL_4_II}
C {devices/lab_pin.sym} 6880 1150 0 0 {name=l579 sig_type=std_logic lab=PL_4_II}
C {devices/lab_pin.sym} 6880 1210 0 0 {name=l580 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 1180 0 0 {name=Xc_4_17
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 1150 0 0 {name=l581 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 1210 0 0 {name=l582 sig_type=std_logic lab=WL_4_II}
C {devices/lab_pin.sym} 7280 1150 0 0 {name=l583 sig_type=std_logic lab=PL_4_II}
C {devices/lab_pin.sym} 7280 1210 0 0 {name=l584 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 1180 0 0 {name=Xc_4_18
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 1150 0 0 {name=l585 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 1210 0 0 {name=l586 sig_type=std_logic lab=WL_4_II}
C {devices/lab_pin.sym} 7680 1150 0 0 {name=l587 sig_type=std_logic lab=PL_4_II}
C {devices/lab_pin.sym} 7680 1210 0 0 {name=l588 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 1180 0 0 {name=Xc_4_19
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 1150 0 0 {name=l589 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 1210 0 0 {name=l590 sig_type=std_logic lab=WL_4_II}
C {devices/lab_pin.sym} 8080 1150 0 0 {name=l591 sig_type=std_logic lab=PL_4_II}
C {devices/lab_pin.sym} 8080 1210 0 0 {name=l592 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 1180 0 0 {name=Xc_4_20
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 1150 0 0 {name=l593 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 1210 0 0 {name=l594 sig_type=std_logic lab=WL_4_II}
C {devices/lab_pin.sym} 8480 1150 0 0 {name=l595 sig_type=std_logic lab=PL_4_II}
C {devices/lab_pin.sym} 8480 1210 0 0 {name=l596 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 1180 0 0 {name=Xc_4_21
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 1150 0 0 {name=l597 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 1210 0 0 {name=l598 sig_type=std_logic lab=WL_4_II}
C {devices/lab_pin.sym} 8880 1150 0 0 {name=l599 sig_type=std_logic lab=PL_4_II}
C {devices/lab_pin.sym} 8880 1210 0 0 {name=l600 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 1180 0 0 {name=Xc_4_22
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 1150 0 0 {name=l601 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 1210 0 0 {name=l602 sig_type=std_logic lab=WL_4_III}
C {devices/lab_pin.sym} 9280 1150 0 0 {name=l603 sig_type=std_logic lab=PL_4_III}
C {devices/lab_pin.sym} 9280 1210 0 0 {name=l604 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 1180 0 0 {name=Xc_4_23
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 1150 0 0 {name=l605 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 1210 0 0 {name=l606 sig_type=std_logic lab=WL_4_III}
C {devices/lab_pin.sym} 9680 1150 0 0 {name=l607 sig_type=std_logic lab=PL_4_III}
C {devices/lab_pin.sym} 9680 1210 0 0 {name=l608 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 1180 0 0 {name=Xc_4_24
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 1150 0 0 {name=l609 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 1210 0 0 {name=l610 sig_type=std_logic lab=WL_4_III}
C {devices/lab_pin.sym} 10080 1150 0 0 {name=l611 sig_type=std_logic lab=PL_4_III}
C {devices/lab_pin.sym} 10080 1210 0 0 {name=l612 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 1180 0 0 {name=Xc_4_25
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 1150 0 0 {name=l613 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 1210 0 0 {name=l614 sig_type=std_logic lab=WL_4_III}
C {devices/lab_pin.sym} 10480 1150 0 0 {name=l615 sig_type=std_logic lab=PL_4_III}
C {devices/lab_pin.sym} 10480 1210 0 0 {name=l616 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 1180 0 0 {name=Xc_4_26
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 1150 0 0 {name=l617 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 1210 0 0 {name=l618 sig_type=std_logic lab=WL_4_III}
C {devices/lab_pin.sym} 10880 1150 0 0 {name=l619 sig_type=std_logic lab=PL_4_III}
C {devices/lab_pin.sym} 10880 1210 0 0 {name=l620 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 1180 0 0 {name=Xc_4_27
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 1150 0 0 {name=l621 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 1210 0 0 {name=l622 sig_type=std_logic lab=WL_4_III}
C {devices/lab_pin.sym} 11280 1150 0 0 {name=l623 sig_type=std_logic lab=PL_4_III}
C {devices/lab_pin.sym} 11280 1210 0 0 {name=l624 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 1180 0 0 {name=Xc_4_28
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 1150 0 0 {name=l625 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 1210 0 0 {name=l626 sig_type=std_logic lab=WL_4_III}
C {devices/lab_pin.sym} 11680 1150 0 0 {name=l627 sig_type=std_logic lab=PL_4_III}
C {devices/lab_pin.sym} 11680 1210 0 0 {name=l628 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 1180 0 0 {name=Xc_4_29
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 1150 0 0 {name=l629 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 1210 0 0 {name=l630 sig_type=std_logic lab=WL_4_III}
C {devices/lab_pin.sym} 12080 1150 0 0 {name=l631 sig_type=std_logic lab=PL_4_III}
C {devices/lab_pin.sym} 12080 1210 0 0 {name=l632 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 1180 0 0 {name=Xc_4_30
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 1150 0 0 {name=l633 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 1210 0 0 {name=l634 sig_type=std_logic lab=WL_4_III}
C {devices/lab_pin.sym} 12480 1150 0 0 {name=l635 sig_type=std_logic lab=PL_4_III}
C {devices/lab_pin.sym} 12480 1210 0 0 {name=l636 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 1180 0 0 {name=Xc_4_31
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 1150 0 0 {name=l637 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 1210 0 0 {name=l638 sig_type=std_logic lab=WL_4_III}
C {devices/lab_pin.sym} 12880 1150 0 0 {name=l639 sig_type=std_logic lab=PL_4_III}
C {devices/lab_pin.sym} 12880 1210 0 0 {name=l640 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 1400 0 0 {name=Xc_5_0
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 1370 0 0 {name=l641 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 1430 0 0 {name=l642 sig_type=std_logic lab=WL_5_I}
C {devices/lab_pin.sym} 480 1370 0 0 {name=l643 sig_type=std_logic lab=PL_5_I}
C {devices/lab_pin.sym} 480 1430 0 0 {name=l644 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 1400 0 0 {name=Xc_5_1
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 1370 0 0 {name=l645 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 1430 0 0 {name=l646 sig_type=std_logic lab=WL_5_I}
C {devices/lab_pin.sym} 880 1370 0 0 {name=l647 sig_type=std_logic lab=PL_5_I}
C {devices/lab_pin.sym} 880 1430 0 0 {name=l648 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 1400 0 0 {name=Xc_5_2
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 1370 0 0 {name=l649 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 1430 0 0 {name=l650 sig_type=std_logic lab=WL_5_I}
C {devices/lab_pin.sym} 1280 1370 0 0 {name=l651 sig_type=std_logic lab=PL_5_I}
C {devices/lab_pin.sym} 1280 1430 0 0 {name=l652 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 1400 0 0 {name=Xc_5_3
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 1370 0 0 {name=l653 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 1430 0 0 {name=l654 sig_type=std_logic lab=WL_5_I}
C {devices/lab_pin.sym} 1680 1370 0 0 {name=l655 sig_type=std_logic lab=PL_5_I}
C {devices/lab_pin.sym} 1680 1430 0 0 {name=l656 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 1400 0 0 {name=Xc_5_4
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 1370 0 0 {name=l657 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 1430 0 0 {name=l658 sig_type=std_logic lab=WL_5_I}
C {devices/lab_pin.sym} 2080 1370 0 0 {name=l659 sig_type=std_logic lab=PL_5_I}
C {devices/lab_pin.sym} 2080 1430 0 0 {name=l660 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 1400 0 0 {name=Xc_5_5
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 1370 0 0 {name=l661 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 1430 0 0 {name=l662 sig_type=std_logic lab=WL_5_I}
C {devices/lab_pin.sym} 2480 1370 0 0 {name=l663 sig_type=std_logic lab=PL_5_I}
C {devices/lab_pin.sym} 2480 1430 0 0 {name=l664 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 1400 0 0 {name=Xc_5_6
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 1370 0 0 {name=l665 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 1430 0 0 {name=l666 sig_type=std_logic lab=WL_5_I}
C {devices/lab_pin.sym} 2880 1370 0 0 {name=l667 sig_type=std_logic lab=PL_5_I}
C {devices/lab_pin.sym} 2880 1430 0 0 {name=l668 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 1400 0 0 {name=Xc_5_7
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 1370 0 0 {name=l669 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 1430 0 0 {name=l670 sig_type=std_logic lab=WL_5_I}
C {devices/lab_pin.sym} 3280 1370 0 0 {name=l671 sig_type=std_logic lab=PL_5_I}
C {devices/lab_pin.sym} 3280 1430 0 0 {name=l672 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 1400 0 0 {name=Xc_5_8
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 1370 0 0 {name=l673 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 1430 0 0 {name=l674 sig_type=std_logic lab=WL_5_I}
C {devices/lab_pin.sym} 3680 1370 0 0 {name=l675 sig_type=std_logic lab=PL_5_I}
C {devices/lab_pin.sym} 3680 1430 0 0 {name=l676 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 1400 0 0 {name=Xc_5_9
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 1370 0 0 {name=l677 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 1430 0 0 {name=l678 sig_type=std_logic lab=WL_5_I}
C {devices/lab_pin.sym} 4080 1370 0 0 {name=l679 sig_type=std_logic lab=PL_5_I}
C {devices/lab_pin.sym} 4080 1430 0 0 {name=l680 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 1400 0 0 {name=Xc_5_10
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 1370 0 0 {name=l681 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 1430 0 0 {name=l682 sig_type=std_logic lab=WL_5_I}
C {devices/lab_pin.sym} 4480 1370 0 0 {name=l683 sig_type=std_logic lab=PL_5_I}
C {devices/lab_pin.sym} 4480 1430 0 0 {name=l684 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 1400 0 0 {name=Xc_5_11
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 1370 0 0 {name=l685 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 1430 0 0 {name=l686 sig_type=std_logic lab=WL_5_II}
C {devices/lab_pin.sym} 4880 1370 0 0 {name=l687 sig_type=std_logic lab=PL_5_II}
C {devices/lab_pin.sym} 4880 1430 0 0 {name=l688 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 1400 0 0 {name=Xc_5_12
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 1370 0 0 {name=l689 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 1430 0 0 {name=l690 sig_type=std_logic lab=WL_5_II}
C {devices/lab_pin.sym} 5280 1370 0 0 {name=l691 sig_type=std_logic lab=PL_5_II}
C {devices/lab_pin.sym} 5280 1430 0 0 {name=l692 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 1400 0 0 {name=Xc_5_13
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 1370 0 0 {name=l693 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 1430 0 0 {name=l694 sig_type=std_logic lab=WL_5_II}
C {devices/lab_pin.sym} 5680 1370 0 0 {name=l695 sig_type=std_logic lab=PL_5_II}
C {devices/lab_pin.sym} 5680 1430 0 0 {name=l696 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 1400 0 0 {name=Xc_5_14
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 1370 0 0 {name=l697 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 1430 0 0 {name=l698 sig_type=std_logic lab=WL_5_II}
C {devices/lab_pin.sym} 6080 1370 0 0 {name=l699 sig_type=std_logic lab=PL_5_II}
C {devices/lab_pin.sym} 6080 1430 0 0 {name=l700 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 1400 0 0 {name=Xc_5_15
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 1370 0 0 {name=l701 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 1430 0 0 {name=l702 sig_type=std_logic lab=WL_5_II}
C {devices/lab_pin.sym} 6480 1370 0 0 {name=l703 sig_type=std_logic lab=PL_5_II}
C {devices/lab_pin.sym} 6480 1430 0 0 {name=l704 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 1400 0 0 {name=Xc_5_16
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 1370 0 0 {name=l705 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 1430 0 0 {name=l706 sig_type=std_logic lab=WL_5_II}
C {devices/lab_pin.sym} 6880 1370 0 0 {name=l707 sig_type=std_logic lab=PL_5_II}
C {devices/lab_pin.sym} 6880 1430 0 0 {name=l708 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 1400 0 0 {name=Xc_5_17
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 1370 0 0 {name=l709 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 1430 0 0 {name=l710 sig_type=std_logic lab=WL_5_II}
C {devices/lab_pin.sym} 7280 1370 0 0 {name=l711 sig_type=std_logic lab=PL_5_II}
C {devices/lab_pin.sym} 7280 1430 0 0 {name=l712 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 1400 0 0 {name=Xc_5_18
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 1370 0 0 {name=l713 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 1430 0 0 {name=l714 sig_type=std_logic lab=WL_5_II}
C {devices/lab_pin.sym} 7680 1370 0 0 {name=l715 sig_type=std_logic lab=PL_5_II}
C {devices/lab_pin.sym} 7680 1430 0 0 {name=l716 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 1400 0 0 {name=Xc_5_19
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 1370 0 0 {name=l717 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 1430 0 0 {name=l718 sig_type=std_logic lab=WL_5_II}
C {devices/lab_pin.sym} 8080 1370 0 0 {name=l719 sig_type=std_logic lab=PL_5_II}
C {devices/lab_pin.sym} 8080 1430 0 0 {name=l720 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 1400 0 0 {name=Xc_5_20
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 1370 0 0 {name=l721 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 1430 0 0 {name=l722 sig_type=std_logic lab=WL_5_II}
C {devices/lab_pin.sym} 8480 1370 0 0 {name=l723 sig_type=std_logic lab=PL_5_II}
C {devices/lab_pin.sym} 8480 1430 0 0 {name=l724 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 1400 0 0 {name=Xc_5_21
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 1370 0 0 {name=l725 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 1430 0 0 {name=l726 sig_type=std_logic lab=WL_5_II}
C {devices/lab_pin.sym} 8880 1370 0 0 {name=l727 sig_type=std_logic lab=PL_5_II}
C {devices/lab_pin.sym} 8880 1430 0 0 {name=l728 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 1400 0 0 {name=Xc_5_22
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 1370 0 0 {name=l729 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 1430 0 0 {name=l730 sig_type=std_logic lab=WL_5_III}
C {devices/lab_pin.sym} 9280 1370 0 0 {name=l731 sig_type=std_logic lab=PL_5_III}
C {devices/lab_pin.sym} 9280 1430 0 0 {name=l732 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 1400 0 0 {name=Xc_5_23
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 1370 0 0 {name=l733 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 1430 0 0 {name=l734 sig_type=std_logic lab=WL_5_III}
C {devices/lab_pin.sym} 9680 1370 0 0 {name=l735 sig_type=std_logic lab=PL_5_III}
C {devices/lab_pin.sym} 9680 1430 0 0 {name=l736 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 1400 0 0 {name=Xc_5_24
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 1370 0 0 {name=l737 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 1430 0 0 {name=l738 sig_type=std_logic lab=WL_5_III}
C {devices/lab_pin.sym} 10080 1370 0 0 {name=l739 sig_type=std_logic lab=PL_5_III}
C {devices/lab_pin.sym} 10080 1430 0 0 {name=l740 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 1400 0 0 {name=Xc_5_25
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 1370 0 0 {name=l741 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 1430 0 0 {name=l742 sig_type=std_logic lab=WL_5_III}
C {devices/lab_pin.sym} 10480 1370 0 0 {name=l743 sig_type=std_logic lab=PL_5_III}
C {devices/lab_pin.sym} 10480 1430 0 0 {name=l744 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 1400 0 0 {name=Xc_5_26
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 1370 0 0 {name=l745 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 1430 0 0 {name=l746 sig_type=std_logic lab=WL_5_III}
C {devices/lab_pin.sym} 10880 1370 0 0 {name=l747 sig_type=std_logic lab=PL_5_III}
C {devices/lab_pin.sym} 10880 1430 0 0 {name=l748 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 1400 0 0 {name=Xc_5_27
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 1370 0 0 {name=l749 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 1430 0 0 {name=l750 sig_type=std_logic lab=WL_5_III}
C {devices/lab_pin.sym} 11280 1370 0 0 {name=l751 sig_type=std_logic lab=PL_5_III}
C {devices/lab_pin.sym} 11280 1430 0 0 {name=l752 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 1400 0 0 {name=Xc_5_28
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 1370 0 0 {name=l753 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 1430 0 0 {name=l754 sig_type=std_logic lab=WL_5_III}
C {devices/lab_pin.sym} 11680 1370 0 0 {name=l755 sig_type=std_logic lab=PL_5_III}
C {devices/lab_pin.sym} 11680 1430 0 0 {name=l756 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 1400 0 0 {name=Xc_5_29
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 1370 0 0 {name=l757 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 1430 0 0 {name=l758 sig_type=std_logic lab=WL_5_III}
C {devices/lab_pin.sym} 12080 1370 0 0 {name=l759 sig_type=std_logic lab=PL_5_III}
C {devices/lab_pin.sym} 12080 1430 0 0 {name=l760 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 1400 0 0 {name=Xc_5_30
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 1370 0 0 {name=l761 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 1430 0 0 {name=l762 sig_type=std_logic lab=WL_5_III}
C {devices/lab_pin.sym} 12480 1370 0 0 {name=l763 sig_type=std_logic lab=PL_5_III}
C {devices/lab_pin.sym} 12480 1430 0 0 {name=l764 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 1400 0 0 {name=Xc_5_31
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 1370 0 0 {name=l765 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 1430 0 0 {name=l766 sig_type=std_logic lab=WL_5_III}
C {devices/lab_pin.sym} 12880 1370 0 0 {name=l767 sig_type=std_logic lab=PL_5_III}
C {devices/lab_pin.sym} 12880 1430 0 0 {name=l768 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 1620 0 0 {name=Xc_6_0
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 1590 0 0 {name=l769 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 1650 0 0 {name=l770 sig_type=std_logic lab=WL_6_I}
C {devices/lab_pin.sym} 480 1590 0 0 {name=l771 sig_type=std_logic lab=PL_6_I}
C {devices/lab_pin.sym} 480 1650 0 0 {name=l772 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 1620 0 0 {name=Xc_6_1
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 1590 0 0 {name=l773 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 1650 0 0 {name=l774 sig_type=std_logic lab=WL_6_I}
C {devices/lab_pin.sym} 880 1590 0 0 {name=l775 sig_type=std_logic lab=PL_6_I}
C {devices/lab_pin.sym} 880 1650 0 0 {name=l776 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 1620 0 0 {name=Xc_6_2
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 1590 0 0 {name=l777 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 1650 0 0 {name=l778 sig_type=std_logic lab=WL_6_I}
C {devices/lab_pin.sym} 1280 1590 0 0 {name=l779 sig_type=std_logic lab=PL_6_I}
C {devices/lab_pin.sym} 1280 1650 0 0 {name=l780 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 1620 0 0 {name=Xc_6_3
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 1590 0 0 {name=l781 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 1650 0 0 {name=l782 sig_type=std_logic lab=WL_6_I}
C {devices/lab_pin.sym} 1680 1590 0 0 {name=l783 sig_type=std_logic lab=PL_6_I}
C {devices/lab_pin.sym} 1680 1650 0 0 {name=l784 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 1620 0 0 {name=Xc_6_4
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 1590 0 0 {name=l785 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 1650 0 0 {name=l786 sig_type=std_logic lab=WL_6_I}
C {devices/lab_pin.sym} 2080 1590 0 0 {name=l787 sig_type=std_logic lab=PL_6_I}
C {devices/lab_pin.sym} 2080 1650 0 0 {name=l788 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 1620 0 0 {name=Xc_6_5
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 1590 0 0 {name=l789 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 1650 0 0 {name=l790 sig_type=std_logic lab=WL_6_I}
C {devices/lab_pin.sym} 2480 1590 0 0 {name=l791 sig_type=std_logic lab=PL_6_I}
C {devices/lab_pin.sym} 2480 1650 0 0 {name=l792 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 1620 0 0 {name=Xc_6_6
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 1590 0 0 {name=l793 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 1650 0 0 {name=l794 sig_type=std_logic lab=WL_6_I}
C {devices/lab_pin.sym} 2880 1590 0 0 {name=l795 sig_type=std_logic lab=PL_6_I}
C {devices/lab_pin.sym} 2880 1650 0 0 {name=l796 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 1620 0 0 {name=Xc_6_7
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 1590 0 0 {name=l797 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 1650 0 0 {name=l798 sig_type=std_logic lab=WL_6_I}
C {devices/lab_pin.sym} 3280 1590 0 0 {name=l799 sig_type=std_logic lab=PL_6_I}
C {devices/lab_pin.sym} 3280 1650 0 0 {name=l800 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 1620 0 0 {name=Xc_6_8
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 1590 0 0 {name=l801 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 1650 0 0 {name=l802 sig_type=std_logic lab=WL_6_I}
C {devices/lab_pin.sym} 3680 1590 0 0 {name=l803 sig_type=std_logic lab=PL_6_I}
C {devices/lab_pin.sym} 3680 1650 0 0 {name=l804 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 1620 0 0 {name=Xc_6_9
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 1590 0 0 {name=l805 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 1650 0 0 {name=l806 sig_type=std_logic lab=WL_6_I}
C {devices/lab_pin.sym} 4080 1590 0 0 {name=l807 sig_type=std_logic lab=PL_6_I}
C {devices/lab_pin.sym} 4080 1650 0 0 {name=l808 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 1620 0 0 {name=Xc_6_10
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 1590 0 0 {name=l809 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 1650 0 0 {name=l810 sig_type=std_logic lab=WL_6_I}
C {devices/lab_pin.sym} 4480 1590 0 0 {name=l811 sig_type=std_logic lab=PL_6_I}
C {devices/lab_pin.sym} 4480 1650 0 0 {name=l812 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 1620 0 0 {name=Xc_6_11
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 1590 0 0 {name=l813 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 1650 0 0 {name=l814 sig_type=std_logic lab=WL_6_II}
C {devices/lab_pin.sym} 4880 1590 0 0 {name=l815 sig_type=std_logic lab=PL_6_II}
C {devices/lab_pin.sym} 4880 1650 0 0 {name=l816 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 1620 0 0 {name=Xc_6_12
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 1590 0 0 {name=l817 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 1650 0 0 {name=l818 sig_type=std_logic lab=WL_6_II}
C {devices/lab_pin.sym} 5280 1590 0 0 {name=l819 sig_type=std_logic lab=PL_6_II}
C {devices/lab_pin.sym} 5280 1650 0 0 {name=l820 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 1620 0 0 {name=Xc_6_13
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 1590 0 0 {name=l821 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 1650 0 0 {name=l822 sig_type=std_logic lab=WL_6_II}
C {devices/lab_pin.sym} 5680 1590 0 0 {name=l823 sig_type=std_logic lab=PL_6_II}
C {devices/lab_pin.sym} 5680 1650 0 0 {name=l824 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 1620 0 0 {name=Xc_6_14
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 1590 0 0 {name=l825 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 1650 0 0 {name=l826 sig_type=std_logic lab=WL_6_II}
C {devices/lab_pin.sym} 6080 1590 0 0 {name=l827 sig_type=std_logic lab=PL_6_II}
C {devices/lab_pin.sym} 6080 1650 0 0 {name=l828 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 1620 0 0 {name=Xc_6_15
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 1590 0 0 {name=l829 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 1650 0 0 {name=l830 sig_type=std_logic lab=WL_6_II}
C {devices/lab_pin.sym} 6480 1590 0 0 {name=l831 sig_type=std_logic lab=PL_6_II}
C {devices/lab_pin.sym} 6480 1650 0 0 {name=l832 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 1620 0 0 {name=Xc_6_16
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 1590 0 0 {name=l833 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 1650 0 0 {name=l834 sig_type=std_logic lab=WL_6_II}
C {devices/lab_pin.sym} 6880 1590 0 0 {name=l835 sig_type=std_logic lab=PL_6_II}
C {devices/lab_pin.sym} 6880 1650 0 0 {name=l836 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 1620 0 0 {name=Xc_6_17
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 1590 0 0 {name=l837 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 1650 0 0 {name=l838 sig_type=std_logic lab=WL_6_II}
C {devices/lab_pin.sym} 7280 1590 0 0 {name=l839 sig_type=std_logic lab=PL_6_II}
C {devices/lab_pin.sym} 7280 1650 0 0 {name=l840 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 1620 0 0 {name=Xc_6_18
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 1590 0 0 {name=l841 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 1650 0 0 {name=l842 sig_type=std_logic lab=WL_6_II}
C {devices/lab_pin.sym} 7680 1590 0 0 {name=l843 sig_type=std_logic lab=PL_6_II}
C {devices/lab_pin.sym} 7680 1650 0 0 {name=l844 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 1620 0 0 {name=Xc_6_19
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 1590 0 0 {name=l845 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 1650 0 0 {name=l846 sig_type=std_logic lab=WL_6_II}
C {devices/lab_pin.sym} 8080 1590 0 0 {name=l847 sig_type=std_logic lab=PL_6_II}
C {devices/lab_pin.sym} 8080 1650 0 0 {name=l848 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 1620 0 0 {name=Xc_6_20
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 1590 0 0 {name=l849 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 1650 0 0 {name=l850 sig_type=std_logic lab=WL_6_II}
C {devices/lab_pin.sym} 8480 1590 0 0 {name=l851 sig_type=std_logic lab=PL_6_II}
C {devices/lab_pin.sym} 8480 1650 0 0 {name=l852 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 1620 0 0 {name=Xc_6_21
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 1590 0 0 {name=l853 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 1650 0 0 {name=l854 sig_type=std_logic lab=WL_6_II}
C {devices/lab_pin.sym} 8880 1590 0 0 {name=l855 sig_type=std_logic lab=PL_6_II}
C {devices/lab_pin.sym} 8880 1650 0 0 {name=l856 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 1620 0 0 {name=Xc_6_22
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 1590 0 0 {name=l857 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 1650 0 0 {name=l858 sig_type=std_logic lab=WL_6_III}
C {devices/lab_pin.sym} 9280 1590 0 0 {name=l859 sig_type=std_logic lab=PL_6_III}
C {devices/lab_pin.sym} 9280 1650 0 0 {name=l860 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 1620 0 0 {name=Xc_6_23
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 1590 0 0 {name=l861 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 1650 0 0 {name=l862 sig_type=std_logic lab=WL_6_III}
C {devices/lab_pin.sym} 9680 1590 0 0 {name=l863 sig_type=std_logic lab=PL_6_III}
C {devices/lab_pin.sym} 9680 1650 0 0 {name=l864 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 1620 0 0 {name=Xc_6_24
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 1590 0 0 {name=l865 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 1650 0 0 {name=l866 sig_type=std_logic lab=WL_6_III}
C {devices/lab_pin.sym} 10080 1590 0 0 {name=l867 sig_type=std_logic lab=PL_6_III}
C {devices/lab_pin.sym} 10080 1650 0 0 {name=l868 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 1620 0 0 {name=Xc_6_25
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 1590 0 0 {name=l869 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 1650 0 0 {name=l870 sig_type=std_logic lab=WL_6_III}
C {devices/lab_pin.sym} 10480 1590 0 0 {name=l871 sig_type=std_logic lab=PL_6_III}
C {devices/lab_pin.sym} 10480 1650 0 0 {name=l872 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 1620 0 0 {name=Xc_6_26
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 1590 0 0 {name=l873 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 1650 0 0 {name=l874 sig_type=std_logic lab=WL_6_III}
C {devices/lab_pin.sym} 10880 1590 0 0 {name=l875 sig_type=std_logic lab=PL_6_III}
C {devices/lab_pin.sym} 10880 1650 0 0 {name=l876 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 1620 0 0 {name=Xc_6_27
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 1590 0 0 {name=l877 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 1650 0 0 {name=l878 sig_type=std_logic lab=WL_6_III}
C {devices/lab_pin.sym} 11280 1590 0 0 {name=l879 sig_type=std_logic lab=PL_6_III}
C {devices/lab_pin.sym} 11280 1650 0 0 {name=l880 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 1620 0 0 {name=Xc_6_28
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 1590 0 0 {name=l881 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 1650 0 0 {name=l882 sig_type=std_logic lab=WL_6_III}
C {devices/lab_pin.sym} 11680 1590 0 0 {name=l883 sig_type=std_logic lab=PL_6_III}
C {devices/lab_pin.sym} 11680 1650 0 0 {name=l884 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 1620 0 0 {name=Xc_6_29
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 1590 0 0 {name=l885 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 1650 0 0 {name=l886 sig_type=std_logic lab=WL_6_III}
C {devices/lab_pin.sym} 12080 1590 0 0 {name=l887 sig_type=std_logic lab=PL_6_III}
C {devices/lab_pin.sym} 12080 1650 0 0 {name=l888 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 1620 0 0 {name=Xc_6_30
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 1590 0 0 {name=l889 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 1650 0 0 {name=l890 sig_type=std_logic lab=WL_6_III}
C {devices/lab_pin.sym} 12480 1590 0 0 {name=l891 sig_type=std_logic lab=PL_6_III}
C {devices/lab_pin.sym} 12480 1650 0 0 {name=l892 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 1620 0 0 {name=Xc_6_31
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 1590 0 0 {name=l893 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 1650 0 0 {name=l894 sig_type=std_logic lab=WL_6_III}
C {devices/lab_pin.sym} 12880 1590 0 0 {name=l895 sig_type=std_logic lab=PL_6_III}
C {devices/lab_pin.sym} 12880 1650 0 0 {name=l896 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 1840 0 0 {name=Xc_7_0
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 1810 0 0 {name=l897 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 1870 0 0 {name=l898 sig_type=std_logic lab=WL_7_I}
C {devices/lab_pin.sym} 480 1810 0 0 {name=l899 sig_type=std_logic lab=PL_7_I}
C {devices/lab_pin.sym} 480 1870 0 0 {name=l900 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 1840 0 0 {name=Xc_7_1
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 1810 0 0 {name=l901 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 1870 0 0 {name=l902 sig_type=std_logic lab=WL_7_I}
C {devices/lab_pin.sym} 880 1810 0 0 {name=l903 sig_type=std_logic lab=PL_7_I}
C {devices/lab_pin.sym} 880 1870 0 0 {name=l904 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 1840 0 0 {name=Xc_7_2
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 1810 0 0 {name=l905 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 1870 0 0 {name=l906 sig_type=std_logic lab=WL_7_I}
C {devices/lab_pin.sym} 1280 1810 0 0 {name=l907 sig_type=std_logic lab=PL_7_I}
C {devices/lab_pin.sym} 1280 1870 0 0 {name=l908 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 1840 0 0 {name=Xc_7_3
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 1810 0 0 {name=l909 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 1870 0 0 {name=l910 sig_type=std_logic lab=WL_7_I}
C {devices/lab_pin.sym} 1680 1810 0 0 {name=l911 sig_type=std_logic lab=PL_7_I}
C {devices/lab_pin.sym} 1680 1870 0 0 {name=l912 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 1840 0 0 {name=Xc_7_4
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 1810 0 0 {name=l913 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 1870 0 0 {name=l914 sig_type=std_logic lab=WL_7_I}
C {devices/lab_pin.sym} 2080 1810 0 0 {name=l915 sig_type=std_logic lab=PL_7_I}
C {devices/lab_pin.sym} 2080 1870 0 0 {name=l916 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 1840 0 0 {name=Xc_7_5
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 1810 0 0 {name=l917 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 1870 0 0 {name=l918 sig_type=std_logic lab=WL_7_I}
C {devices/lab_pin.sym} 2480 1810 0 0 {name=l919 sig_type=std_logic lab=PL_7_I}
C {devices/lab_pin.sym} 2480 1870 0 0 {name=l920 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 1840 0 0 {name=Xc_7_6
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 1810 0 0 {name=l921 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 1870 0 0 {name=l922 sig_type=std_logic lab=WL_7_I}
C {devices/lab_pin.sym} 2880 1810 0 0 {name=l923 sig_type=std_logic lab=PL_7_I}
C {devices/lab_pin.sym} 2880 1870 0 0 {name=l924 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 1840 0 0 {name=Xc_7_7
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 1810 0 0 {name=l925 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 1870 0 0 {name=l926 sig_type=std_logic lab=WL_7_I}
C {devices/lab_pin.sym} 3280 1810 0 0 {name=l927 sig_type=std_logic lab=PL_7_I}
C {devices/lab_pin.sym} 3280 1870 0 0 {name=l928 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 1840 0 0 {name=Xc_7_8
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 1810 0 0 {name=l929 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 1870 0 0 {name=l930 sig_type=std_logic lab=WL_7_I}
C {devices/lab_pin.sym} 3680 1810 0 0 {name=l931 sig_type=std_logic lab=PL_7_I}
C {devices/lab_pin.sym} 3680 1870 0 0 {name=l932 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 1840 0 0 {name=Xc_7_9
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 1810 0 0 {name=l933 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 1870 0 0 {name=l934 sig_type=std_logic lab=WL_7_I}
C {devices/lab_pin.sym} 4080 1810 0 0 {name=l935 sig_type=std_logic lab=PL_7_I}
C {devices/lab_pin.sym} 4080 1870 0 0 {name=l936 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 1840 0 0 {name=Xc_7_10
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 1810 0 0 {name=l937 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 1870 0 0 {name=l938 sig_type=std_logic lab=WL_7_I}
C {devices/lab_pin.sym} 4480 1810 0 0 {name=l939 sig_type=std_logic lab=PL_7_I}
C {devices/lab_pin.sym} 4480 1870 0 0 {name=l940 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 1840 0 0 {name=Xc_7_11
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 1810 0 0 {name=l941 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 1870 0 0 {name=l942 sig_type=std_logic lab=WL_7_II}
C {devices/lab_pin.sym} 4880 1810 0 0 {name=l943 sig_type=std_logic lab=PL_7_II}
C {devices/lab_pin.sym} 4880 1870 0 0 {name=l944 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 1840 0 0 {name=Xc_7_12
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 1810 0 0 {name=l945 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 1870 0 0 {name=l946 sig_type=std_logic lab=WL_7_II}
C {devices/lab_pin.sym} 5280 1810 0 0 {name=l947 sig_type=std_logic lab=PL_7_II}
C {devices/lab_pin.sym} 5280 1870 0 0 {name=l948 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 1840 0 0 {name=Xc_7_13
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 1810 0 0 {name=l949 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 1870 0 0 {name=l950 sig_type=std_logic lab=WL_7_II}
C {devices/lab_pin.sym} 5680 1810 0 0 {name=l951 sig_type=std_logic lab=PL_7_II}
C {devices/lab_pin.sym} 5680 1870 0 0 {name=l952 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 1840 0 0 {name=Xc_7_14
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 1810 0 0 {name=l953 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 1870 0 0 {name=l954 sig_type=std_logic lab=WL_7_II}
C {devices/lab_pin.sym} 6080 1810 0 0 {name=l955 sig_type=std_logic lab=PL_7_II}
C {devices/lab_pin.sym} 6080 1870 0 0 {name=l956 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 1840 0 0 {name=Xc_7_15
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 1810 0 0 {name=l957 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 1870 0 0 {name=l958 sig_type=std_logic lab=WL_7_II}
C {devices/lab_pin.sym} 6480 1810 0 0 {name=l959 sig_type=std_logic lab=PL_7_II}
C {devices/lab_pin.sym} 6480 1870 0 0 {name=l960 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 1840 0 0 {name=Xc_7_16
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 1810 0 0 {name=l961 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 1870 0 0 {name=l962 sig_type=std_logic lab=WL_7_II}
C {devices/lab_pin.sym} 6880 1810 0 0 {name=l963 sig_type=std_logic lab=PL_7_II}
C {devices/lab_pin.sym} 6880 1870 0 0 {name=l964 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 1840 0 0 {name=Xc_7_17
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 1810 0 0 {name=l965 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 1870 0 0 {name=l966 sig_type=std_logic lab=WL_7_II}
C {devices/lab_pin.sym} 7280 1810 0 0 {name=l967 sig_type=std_logic lab=PL_7_II}
C {devices/lab_pin.sym} 7280 1870 0 0 {name=l968 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 1840 0 0 {name=Xc_7_18
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 1810 0 0 {name=l969 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 1870 0 0 {name=l970 sig_type=std_logic lab=WL_7_II}
C {devices/lab_pin.sym} 7680 1810 0 0 {name=l971 sig_type=std_logic lab=PL_7_II}
C {devices/lab_pin.sym} 7680 1870 0 0 {name=l972 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 1840 0 0 {name=Xc_7_19
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 1810 0 0 {name=l973 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 1870 0 0 {name=l974 sig_type=std_logic lab=WL_7_II}
C {devices/lab_pin.sym} 8080 1810 0 0 {name=l975 sig_type=std_logic lab=PL_7_II}
C {devices/lab_pin.sym} 8080 1870 0 0 {name=l976 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 1840 0 0 {name=Xc_7_20
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 1810 0 0 {name=l977 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 1870 0 0 {name=l978 sig_type=std_logic lab=WL_7_II}
C {devices/lab_pin.sym} 8480 1810 0 0 {name=l979 sig_type=std_logic lab=PL_7_II}
C {devices/lab_pin.sym} 8480 1870 0 0 {name=l980 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 1840 0 0 {name=Xc_7_21
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 1810 0 0 {name=l981 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 1870 0 0 {name=l982 sig_type=std_logic lab=WL_7_II}
C {devices/lab_pin.sym} 8880 1810 0 0 {name=l983 sig_type=std_logic lab=PL_7_II}
C {devices/lab_pin.sym} 8880 1870 0 0 {name=l984 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 1840 0 0 {name=Xc_7_22
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 1810 0 0 {name=l985 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 1870 0 0 {name=l986 sig_type=std_logic lab=WL_7_III}
C {devices/lab_pin.sym} 9280 1810 0 0 {name=l987 sig_type=std_logic lab=PL_7_III}
C {devices/lab_pin.sym} 9280 1870 0 0 {name=l988 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 1840 0 0 {name=Xc_7_23
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 1810 0 0 {name=l989 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 1870 0 0 {name=l990 sig_type=std_logic lab=WL_7_III}
C {devices/lab_pin.sym} 9680 1810 0 0 {name=l991 sig_type=std_logic lab=PL_7_III}
C {devices/lab_pin.sym} 9680 1870 0 0 {name=l992 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 1840 0 0 {name=Xc_7_24
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 1810 0 0 {name=l993 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 1870 0 0 {name=l994 sig_type=std_logic lab=WL_7_III}
C {devices/lab_pin.sym} 10080 1810 0 0 {name=l995 sig_type=std_logic lab=PL_7_III}
C {devices/lab_pin.sym} 10080 1870 0 0 {name=l996 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 1840 0 0 {name=Xc_7_25
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 1810 0 0 {name=l997 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 1870 0 0 {name=l998 sig_type=std_logic lab=WL_7_III}
C {devices/lab_pin.sym} 10480 1810 0 0 {name=l999 sig_type=std_logic lab=PL_7_III}
C {devices/lab_pin.sym} 10480 1870 0 0 {name=l1000 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 1840 0 0 {name=Xc_7_26
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 1810 0 0 {name=l1001 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 1870 0 0 {name=l1002 sig_type=std_logic lab=WL_7_III}
C {devices/lab_pin.sym} 10880 1810 0 0 {name=l1003 sig_type=std_logic lab=PL_7_III}
C {devices/lab_pin.sym} 10880 1870 0 0 {name=l1004 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 1840 0 0 {name=Xc_7_27
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 1810 0 0 {name=l1005 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 1870 0 0 {name=l1006 sig_type=std_logic lab=WL_7_III}
C {devices/lab_pin.sym} 11280 1810 0 0 {name=l1007 sig_type=std_logic lab=PL_7_III}
C {devices/lab_pin.sym} 11280 1870 0 0 {name=l1008 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 1840 0 0 {name=Xc_7_28
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 1810 0 0 {name=l1009 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 1870 0 0 {name=l1010 sig_type=std_logic lab=WL_7_III}
C {devices/lab_pin.sym} 11680 1810 0 0 {name=l1011 sig_type=std_logic lab=PL_7_III}
C {devices/lab_pin.sym} 11680 1870 0 0 {name=l1012 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 1840 0 0 {name=Xc_7_29
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 1810 0 0 {name=l1013 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 1870 0 0 {name=l1014 sig_type=std_logic lab=WL_7_III}
C {devices/lab_pin.sym} 12080 1810 0 0 {name=l1015 sig_type=std_logic lab=PL_7_III}
C {devices/lab_pin.sym} 12080 1870 0 0 {name=l1016 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 1840 0 0 {name=Xc_7_30
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 1810 0 0 {name=l1017 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 1870 0 0 {name=l1018 sig_type=std_logic lab=WL_7_III}
C {devices/lab_pin.sym} 12480 1810 0 0 {name=l1019 sig_type=std_logic lab=PL_7_III}
C {devices/lab_pin.sym} 12480 1870 0 0 {name=l1020 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 1840 0 0 {name=Xc_7_31
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 1810 0 0 {name=l1021 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 1870 0 0 {name=l1022 sig_type=std_logic lab=WL_7_III}
C {devices/lab_pin.sym} 12880 1810 0 0 {name=l1023 sig_type=std_logic lab=PL_7_III}
C {devices/lab_pin.sym} 12880 1870 0 0 {name=l1024 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 2060 0 0 {name=Xc_8_0
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 2030 0 0 {name=l1025 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 2090 0 0 {name=l1026 sig_type=std_logic lab=WL_8_I}
C {devices/lab_pin.sym} 480 2030 0 0 {name=l1027 sig_type=std_logic lab=PL_8_I}
C {devices/lab_pin.sym} 480 2090 0 0 {name=l1028 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 2060 0 0 {name=Xc_8_1
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 2030 0 0 {name=l1029 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 2090 0 0 {name=l1030 sig_type=std_logic lab=WL_8_I}
C {devices/lab_pin.sym} 880 2030 0 0 {name=l1031 sig_type=std_logic lab=PL_8_I}
C {devices/lab_pin.sym} 880 2090 0 0 {name=l1032 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 2060 0 0 {name=Xc_8_2
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 2030 0 0 {name=l1033 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 2090 0 0 {name=l1034 sig_type=std_logic lab=WL_8_I}
C {devices/lab_pin.sym} 1280 2030 0 0 {name=l1035 sig_type=std_logic lab=PL_8_I}
C {devices/lab_pin.sym} 1280 2090 0 0 {name=l1036 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 2060 0 0 {name=Xc_8_3
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 2030 0 0 {name=l1037 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 2090 0 0 {name=l1038 sig_type=std_logic lab=WL_8_I}
C {devices/lab_pin.sym} 1680 2030 0 0 {name=l1039 sig_type=std_logic lab=PL_8_I}
C {devices/lab_pin.sym} 1680 2090 0 0 {name=l1040 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 2060 0 0 {name=Xc_8_4
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 2030 0 0 {name=l1041 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 2090 0 0 {name=l1042 sig_type=std_logic lab=WL_8_I}
C {devices/lab_pin.sym} 2080 2030 0 0 {name=l1043 sig_type=std_logic lab=PL_8_I}
C {devices/lab_pin.sym} 2080 2090 0 0 {name=l1044 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 2060 0 0 {name=Xc_8_5
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 2030 0 0 {name=l1045 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 2090 0 0 {name=l1046 sig_type=std_logic lab=WL_8_I}
C {devices/lab_pin.sym} 2480 2030 0 0 {name=l1047 sig_type=std_logic lab=PL_8_I}
C {devices/lab_pin.sym} 2480 2090 0 0 {name=l1048 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 2060 0 0 {name=Xc_8_6
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 2030 0 0 {name=l1049 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 2090 0 0 {name=l1050 sig_type=std_logic lab=WL_8_I}
C {devices/lab_pin.sym} 2880 2030 0 0 {name=l1051 sig_type=std_logic lab=PL_8_I}
C {devices/lab_pin.sym} 2880 2090 0 0 {name=l1052 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 2060 0 0 {name=Xc_8_7
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 2030 0 0 {name=l1053 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 2090 0 0 {name=l1054 sig_type=std_logic lab=WL_8_I}
C {devices/lab_pin.sym} 3280 2030 0 0 {name=l1055 sig_type=std_logic lab=PL_8_I}
C {devices/lab_pin.sym} 3280 2090 0 0 {name=l1056 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 2060 0 0 {name=Xc_8_8
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 2030 0 0 {name=l1057 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 2090 0 0 {name=l1058 sig_type=std_logic lab=WL_8_I}
C {devices/lab_pin.sym} 3680 2030 0 0 {name=l1059 sig_type=std_logic lab=PL_8_I}
C {devices/lab_pin.sym} 3680 2090 0 0 {name=l1060 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 2060 0 0 {name=Xc_8_9
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 2030 0 0 {name=l1061 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 2090 0 0 {name=l1062 sig_type=std_logic lab=WL_8_I}
C {devices/lab_pin.sym} 4080 2030 0 0 {name=l1063 sig_type=std_logic lab=PL_8_I}
C {devices/lab_pin.sym} 4080 2090 0 0 {name=l1064 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 2060 0 0 {name=Xc_8_10
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 2030 0 0 {name=l1065 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 2090 0 0 {name=l1066 sig_type=std_logic lab=WL_8_I}
C {devices/lab_pin.sym} 4480 2030 0 0 {name=l1067 sig_type=std_logic lab=PL_8_I}
C {devices/lab_pin.sym} 4480 2090 0 0 {name=l1068 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 2060 0 0 {name=Xc_8_11
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 2030 0 0 {name=l1069 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 2090 0 0 {name=l1070 sig_type=std_logic lab=WL_8_II}
C {devices/lab_pin.sym} 4880 2030 0 0 {name=l1071 sig_type=std_logic lab=PL_8_II}
C {devices/lab_pin.sym} 4880 2090 0 0 {name=l1072 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 2060 0 0 {name=Xc_8_12
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 2030 0 0 {name=l1073 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 2090 0 0 {name=l1074 sig_type=std_logic lab=WL_8_II}
C {devices/lab_pin.sym} 5280 2030 0 0 {name=l1075 sig_type=std_logic lab=PL_8_II}
C {devices/lab_pin.sym} 5280 2090 0 0 {name=l1076 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 2060 0 0 {name=Xc_8_13
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 2030 0 0 {name=l1077 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 2090 0 0 {name=l1078 sig_type=std_logic lab=WL_8_II}
C {devices/lab_pin.sym} 5680 2030 0 0 {name=l1079 sig_type=std_logic lab=PL_8_II}
C {devices/lab_pin.sym} 5680 2090 0 0 {name=l1080 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 2060 0 0 {name=Xc_8_14
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 2030 0 0 {name=l1081 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 2090 0 0 {name=l1082 sig_type=std_logic lab=WL_8_II}
C {devices/lab_pin.sym} 6080 2030 0 0 {name=l1083 sig_type=std_logic lab=PL_8_II}
C {devices/lab_pin.sym} 6080 2090 0 0 {name=l1084 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 2060 0 0 {name=Xc_8_15
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 2030 0 0 {name=l1085 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 2090 0 0 {name=l1086 sig_type=std_logic lab=WL_8_II}
C {devices/lab_pin.sym} 6480 2030 0 0 {name=l1087 sig_type=std_logic lab=PL_8_II}
C {devices/lab_pin.sym} 6480 2090 0 0 {name=l1088 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 2060 0 0 {name=Xc_8_16
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 2030 0 0 {name=l1089 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 2090 0 0 {name=l1090 sig_type=std_logic lab=WL_8_II}
C {devices/lab_pin.sym} 6880 2030 0 0 {name=l1091 sig_type=std_logic lab=PL_8_II}
C {devices/lab_pin.sym} 6880 2090 0 0 {name=l1092 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 2060 0 0 {name=Xc_8_17
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 2030 0 0 {name=l1093 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 2090 0 0 {name=l1094 sig_type=std_logic lab=WL_8_II}
C {devices/lab_pin.sym} 7280 2030 0 0 {name=l1095 sig_type=std_logic lab=PL_8_II}
C {devices/lab_pin.sym} 7280 2090 0 0 {name=l1096 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 2060 0 0 {name=Xc_8_18
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 2030 0 0 {name=l1097 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 2090 0 0 {name=l1098 sig_type=std_logic lab=WL_8_II}
C {devices/lab_pin.sym} 7680 2030 0 0 {name=l1099 sig_type=std_logic lab=PL_8_II}
C {devices/lab_pin.sym} 7680 2090 0 0 {name=l1100 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 2060 0 0 {name=Xc_8_19
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 2030 0 0 {name=l1101 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 2090 0 0 {name=l1102 sig_type=std_logic lab=WL_8_II}
C {devices/lab_pin.sym} 8080 2030 0 0 {name=l1103 sig_type=std_logic lab=PL_8_II}
C {devices/lab_pin.sym} 8080 2090 0 0 {name=l1104 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 2060 0 0 {name=Xc_8_20
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 2030 0 0 {name=l1105 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 2090 0 0 {name=l1106 sig_type=std_logic lab=WL_8_II}
C {devices/lab_pin.sym} 8480 2030 0 0 {name=l1107 sig_type=std_logic lab=PL_8_II}
C {devices/lab_pin.sym} 8480 2090 0 0 {name=l1108 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 2060 0 0 {name=Xc_8_21
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 2030 0 0 {name=l1109 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 2090 0 0 {name=l1110 sig_type=std_logic lab=WL_8_II}
C {devices/lab_pin.sym} 8880 2030 0 0 {name=l1111 sig_type=std_logic lab=PL_8_II}
C {devices/lab_pin.sym} 8880 2090 0 0 {name=l1112 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 2060 0 0 {name=Xc_8_22
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 2030 0 0 {name=l1113 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 2090 0 0 {name=l1114 sig_type=std_logic lab=WL_8_III}
C {devices/lab_pin.sym} 9280 2030 0 0 {name=l1115 sig_type=std_logic lab=PL_8_III}
C {devices/lab_pin.sym} 9280 2090 0 0 {name=l1116 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 2060 0 0 {name=Xc_8_23
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 2030 0 0 {name=l1117 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 2090 0 0 {name=l1118 sig_type=std_logic lab=WL_8_III}
C {devices/lab_pin.sym} 9680 2030 0 0 {name=l1119 sig_type=std_logic lab=PL_8_III}
C {devices/lab_pin.sym} 9680 2090 0 0 {name=l1120 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 2060 0 0 {name=Xc_8_24
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 2030 0 0 {name=l1121 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 2090 0 0 {name=l1122 sig_type=std_logic lab=WL_8_III}
C {devices/lab_pin.sym} 10080 2030 0 0 {name=l1123 sig_type=std_logic lab=PL_8_III}
C {devices/lab_pin.sym} 10080 2090 0 0 {name=l1124 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 2060 0 0 {name=Xc_8_25
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 2030 0 0 {name=l1125 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 2090 0 0 {name=l1126 sig_type=std_logic lab=WL_8_III}
C {devices/lab_pin.sym} 10480 2030 0 0 {name=l1127 sig_type=std_logic lab=PL_8_III}
C {devices/lab_pin.sym} 10480 2090 0 0 {name=l1128 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 2060 0 0 {name=Xc_8_26
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 2030 0 0 {name=l1129 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 2090 0 0 {name=l1130 sig_type=std_logic lab=WL_8_III}
C {devices/lab_pin.sym} 10880 2030 0 0 {name=l1131 sig_type=std_logic lab=PL_8_III}
C {devices/lab_pin.sym} 10880 2090 0 0 {name=l1132 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 2060 0 0 {name=Xc_8_27
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 2030 0 0 {name=l1133 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 2090 0 0 {name=l1134 sig_type=std_logic lab=WL_8_III}
C {devices/lab_pin.sym} 11280 2030 0 0 {name=l1135 sig_type=std_logic lab=PL_8_III}
C {devices/lab_pin.sym} 11280 2090 0 0 {name=l1136 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 2060 0 0 {name=Xc_8_28
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 2030 0 0 {name=l1137 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 2090 0 0 {name=l1138 sig_type=std_logic lab=WL_8_III}
C {devices/lab_pin.sym} 11680 2030 0 0 {name=l1139 sig_type=std_logic lab=PL_8_III}
C {devices/lab_pin.sym} 11680 2090 0 0 {name=l1140 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 2060 0 0 {name=Xc_8_29
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 2030 0 0 {name=l1141 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 2090 0 0 {name=l1142 sig_type=std_logic lab=WL_8_III}
C {devices/lab_pin.sym} 12080 2030 0 0 {name=l1143 sig_type=std_logic lab=PL_8_III}
C {devices/lab_pin.sym} 12080 2090 0 0 {name=l1144 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 2060 0 0 {name=Xc_8_30
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 2030 0 0 {name=l1145 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 2090 0 0 {name=l1146 sig_type=std_logic lab=WL_8_III}
C {devices/lab_pin.sym} 12480 2030 0 0 {name=l1147 sig_type=std_logic lab=PL_8_III}
C {devices/lab_pin.sym} 12480 2090 0 0 {name=l1148 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 2060 0 0 {name=Xc_8_31
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 2030 0 0 {name=l1149 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 2090 0 0 {name=l1150 sig_type=std_logic lab=WL_8_III}
C {devices/lab_pin.sym} 12880 2030 0 0 {name=l1151 sig_type=std_logic lab=PL_8_III}
C {devices/lab_pin.sym} 12880 2090 0 0 {name=l1152 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 2280 0 0 {name=Xc_9_0
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 2250 0 0 {name=l1153 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 2310 0 0 {name=l1154 sig_type=std_logic lab=WL_9_I}
C {devices/lab_pin.sym} 480 2250 0 0 {name=l1155 sig_type=std_logic lab=PL_9_I}
C {devices/lab_pin.sym} 480 2310 0 0 {name=l1156 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 2280 0 0 {name=Xc_9_1
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 2250 0 0 {name=l1157 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 2310 0 0 {name=l1158 sig_type=std_logic lab=WL_9_I}
C {devices/lab_pin.sym} 880 2250 0 0 {name=l1159 sig_type=std_logic lab=PL_9_I}
C {devices/lab_pin.sym} 880 2310 0 0 {name=l1160 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 2280 0 0 {name=Xc_9_2
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 2250 0 0 {name=l1161 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 2310 0 0 {name=l1162 sig_type=std_logic lab=WL_9_I}
C {devices/lab_pin.sym} 1280 2250 0 0 {name=l1163 sig_type=std_logic lab=PL_9_I}
C {devices/lab_pin.sym} 1280 2310 0 0 {name=l1164 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 2280 0 0 {name=Xc_9_3
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 2250 0 0 {name=l1165 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 2310 0 0 {name=l1166 sig_type=std_logic lab=WL_9_I}
C {devices/lab_pin.sym} 1680 2250 0 0 {name=l1167 sig_type=std_logic lab=PL_9_I}
C {devices/lab_pin.sym} 1680 2310 0 0 {name=l1168 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 2280 0 0 {name=Xc_9_4
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 2250 0 0 {name=l1169 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 2310 0 0 {name=l1170 sig_type=std_logic lab=WL_9_I}
C {devices/lab_pin.sym} 2080 2250 0 0 {name=l1171 sig_type=std_logic lab=PL_9_I}
C {devices/lab_pin.sym} 2080 2310 0 0 {name=l1172 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 2280 0 0 {name=Xc_9_5
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 2250 0 0 {name=l1173 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 2310 0 0 {name=l1174 sig_type=std_logic lab=WL_9_I}
C {devices/lab_pin.sym} 2480 2250 0 0 {name=l1175 sig_type=std_logic lab=PL_9_I}
C {devices/lab_pin.sym} 2480 2310 0 0 {name=l1176 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 2280 0 0 {name=Xc_9_6
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 2250 0 0 {name=l1177 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 2310 0 0 {name=l1178 sig_type=std_logic lab=WL_9_I}
C {devices/lab_pin.sym} 2880 2250 0 0 {name=l1179 sig_type=std_logic lab=PL_9_I}
C {devices/lab_pin.sym} 2880 2310 0 0 {name=l1180 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 2280 0 0 {name=Xc_9_7
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 2250 0 0 {name=l1181 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 2310 0 0 {name=l1182 sig_type=std_logic lab=WL_9_I}
C {devices/lab_pin.sym} 3280 2250 0 0 {name=l1183 sig_type=std_logic lab=PL_9_I}
C {devices/lab_pin.sym} 3280 2310 0 0 {name=l1184 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 2280 0 0 {name=Xc_9_8
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 2250 0 0 {name=l1185 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 2310 0 0 {name=l1186 sig_type=std_logic lab=WL_9_I}
C {devices/lab_pin.sym} 3680 2250 0 0 {name=l1187 sig_type=std_logic lab=PL_9_I}
C {devices/lab_pin.sym} 3680 2310 0 0 {name=l1188 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 2280 0 0 {name=Xc_9_9
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 2250 0 0 {name=l1189 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 2310 0 0 {name=l1190 sig_type=std_logic lab=WL_9_I}
C {devices/lab_pin.sym} 4080 2250 0 0 {name=l1191 sig_type=std_logic lab=PL_9_I}
C {devices/lab_pin.sym} 4080 2310 0 0 {name=l1192 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 2280 0 0 {name=Xc_9_10
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 2250 0 0 {name=l1193 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 2310 0 0 {name=l1194 sig_type=std_logic lab=WL_9_I}
C {devices/lab_pin.sym} 4480 2250 0 0 {name=l1195 sig_type=std_logic lab=PL_9_I}
C {devices/lab_pin.sym} 4480 2310 0 0 {name=l1196 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 2280 0 0 {name=Xc_9_11
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 2250 0 0 {name=l1197 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 2310 0 0 {name=l1198 sig_type=std_logic lab=WL_9_II}
C {devices/lab_pin.sym} 4880 2250 0 0 {name=l1199 sig_type=std_logic lab=PL_9_II}
C {devices/lab_pin.sym} 4880 2310 0 0 {name=l1200 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 2280 0 0 {name=Xc_9_12
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 2250 0 0 {name=l1201 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 2310 0 0 {name=l1202 sig_type=std_logic lab=WL_9_II}
C {devices/lab_pin.sym} 5280 2250 0 0 {name=l1203 sig_type=std_logic lab=PL_9_II}
C {devices/lab_pin.sym} 5280 2310 0 0 {name=l1204 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 2280 0 0 {name=Xc_9_13
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 2250 0 0 {name=l1205 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 2310 0 0 {name=l1206 sig_type=std_logic lab=WL_9_II}
C {devices/lab_pin.sym} 5680 2250 0 0 {name=l1207 sig_type=std_logic lab=PL_9_II}
C {devices/lab_pin.sym} 5680 2310 0 0 {name=l1208 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 2280 0 0 {name=Xc_9_14
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 2250 0 0 {name=l1209 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 2310 0 0 {name=l1210 sig_type=std_logic lab=WL_9_II}
C {devices/lab_pin.sym} 6080 2250 0 0 {name=l1211 sig_type=std_logic lab=PL_9_II}
C {devices/lab_pin.sym} 6080 2310 0 0 {name=l1212 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 2280 0 0 {name=Xc_9_15
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 2250 0 0 {name=l1213 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 2310 0 0 {name=l1214 sig_type=std_logic lab=WL_9_II}
C {devices/lab_pin.sym} 6480 2250 0 0 {name=l1215 sig_type=std_logic lab=PL_9_II}
C {devices/lab_pin.sym} 6480 2310 0 0 {name=l1216 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 2280 0 0 {name=Xc_9_16
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 2250 0 0 {name=l1217 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 2310 0 0 {name=l1218 sig_type=std_logic lab=WL_9_II}
C {devices/lab_pin.sym} 6880 2250 0 0 {name=l1219 sig_type=std_logic lab=PL_9_II}
C {devices/lab_pin.sym} 6880 2310 0 0 {name=l1220 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 2280 0 0 {name=Xc_9_17
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 2250 0 0 {name=l1221 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 2310 0 0 {name=l1222 sig_type=std_logic lab=WL_9_II}
C {devices/lab_pin.sym} 7280 2250 0 0 {name=l1223 sig_type=std_logic lab=PL_9_II}
C {devices/lab_pin.sym} 7280 2310 0 0 {name=l1224 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 2280 0 0 {name=Xc_9_18
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 2250 0 0 {name=l1225 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 2310 0 0 {name=l1226 sig_type=std_logic lab=WL_9_II}
C {devices/lab_pin.sym} 7680 2250 0 0 {name=l1227 sig_type=std_logic lab=PL_9_II}
C {devices/lab_pin.sym} 7680 2310 0 0 {name=l1228 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 2280 0 0 {name=Xc_9_19
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 2250 0 0 {name=l1229 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 2310 0 0 {name=l1230 sig_type=std_logic lab=WL_9_II}
C {devices/lab_pin.sym} 8080 2250 0 0 {name=l1231 sig_type=std_logic lab=PL_9_II}
C {devices/lab_pin.sym} 8080 2310 0 0 {name=l1232 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 2280 0 0 {name=Xc_9_20
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 2250 0 0 {name=l1233 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 2310 0 0 {name=l1234 sig_type=std_logic lab=WL_9_II}
C {devices/lab_pin.sym} 8480 2250 0 0 {name=l1235 sig_type=std_logic lab=PL_9_II}
C {devices/lab_pin.sym} 8480 2310 0 0 {name=l1236 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 2280 0 0 {name=Xc_9_21
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 2250 0 0 {name=l1237 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 2310 0 0 {name=l1238 sig_type=std_logic lab=WL_9_II}
C {devices/lab_pin.sym} 8880 2250 0 0 {name=l1239 sig_type=std_logic lab=PL_9_II}
C {devices/lab_pin.sym} 8880 2310 0 0 {name=l1240 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 2280 0 0 {name=Xc_9_22
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 2250 0 0 {name=l1241 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 2310 0 0 {name=l1242 sig_type=std_logic lab=WL_9_III}
C {devices/lab_pin.sym} 9280 2250 0 0 {name=l1243 sig_type=std_logic lab=PL_9_III}
C {devices/lab_pin.sym} 9280 2310 0 0 {name=l1244 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 2280 0 0 {name=Xc_9_23
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 2250 0 0 {name=l1245 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 2310 0 0 {name=l1246 sig_type=std_logic lab=WL_9_III}
C {devices/lab_pin.sym} 9680 2250 0 0 {name=l1247 sig_type=std_logic lab=PL_9_III}
C {devices/lab_pin.sym} 9680 2310 0 0 {name=l1248 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 2280 0 0 {name=Xc_9_24
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 2250 0 0 {name=l1249 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 2310 0 0 {name=l1250 sig_type=std_logic lab=WL_9_III}
C {devices/lab_pin.sym} 10080 2250 0 0 {name=l1251 sig_type=std_logic lab=PL_9_III}
C {devices/lab_pin.sym} 10080 2310 0 0 {name=l1252 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 2280 0 0 {name=Xc_9_25
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 2250 0 0 {name=l1253 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 2310 0 0 {name=l1254 sig_type=std_logic lab=WL_9_III}
C {devices/lab_pin.sym} 10480 2250 0 0 {name=l1255 sig_type=std_logic lab=PL_9_III}
C {devices/lab_pin.sym} 10480 2310 0 0 {name=l1256 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 2280 0 0 {name=Xc_9_26
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 2250 0 0 {name=l1257 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 2310 0 0 {name=l1258 sig_type=std_logic lab=WL_9_III}
C {devices/lab_pin.sym} 10880 2250 0 0 {name=l1259 sig_type=std_logic lab=PL_9_III}
C {devices/lab_pin.sym} 10880 2310 0 0 {name=l1260 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 2280 0 0 {name=Xc_9_27
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 2250 0 0 {name=l1261 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 2310 0 0 {name=l1262 sig_type=std_logic lab=WL_9_III}
C {devices/lab_pin.sym} 11280 2250 0 0 {name=l1263 sig_type=std_logic lab=PL_9_III}
C {devices/lab_pin.sym} 11280 2310 0 0 {name=l1264 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 2280 0 0 {name=Xc_9_28
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 2250 0 0 {name=l1265 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 2310 0 0 {name=l1266 sig_type=std_logic lab=WL_9_III}
C {devices/lab_pin.sym} 11680 2250 0 0 {name=l1267 sig_type=std_logic lab=PL_9_III}
C {devices/lab_pin.sym} 11680 2310 0 0 {name=l1268 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 2280 0 0 {name=Xc_9_29
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 2250 0 0 {name=l1269 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 2310 0 0 {name=l1270 sig_type=std_logic lab=WL_9_III}
C {devices/lab_pin.sym} 12080 2250 0 0 {name=l1271 sig_type=std_logic lab=PL_9_III}
C {devices/lab_pin.sym} 12080 2310 0 0 {name=l1272 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 2280 0 0 {name=Xc_9_30
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 2250 0 0 {name=l1273 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 2310 0 0 {name=l1274 sig_type=std_logic lab=WL_9_III}
C {devices/lab_pin.sym} 12480 2250 0 0 {name=l1275 sig_type=std_logic lab=PL_9_III}
C {devices/lab_pin.sym} 12480 2310 0 0 {name=l1276 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 2280 0 0 {name=Xc_9_31
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 2250 0 0 {name=l1277 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 2310 0 0 {name=l1278 sig_type=std_logic lab=WL_9_III}
C {devices/lab_pin.sym} 12880 2250 0 0 {name=l1279 sig_type=std_logic lab=PL_9_III}
C {devices/lab_pin.sym} 12880 2310 0 0 {name=l1280 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 2500 0 0 {name=Xc_10_0
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 2470 0 0 {name=l1281 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 2530 0 0 {name=l1282 sig_type=std_logic lab=WL_10_I}
C {devices/lab_pin.sym} 480 2470 0 0 {name=l1283 sig_type=std_logic lab=PL_10_I}
C {devices/lab_pin.sym} 480 2530 0 0 {name=l1284 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 2500 0 0 {name=Xc_10_1
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 2470 0 0 {name=l1285 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 2530 0 0 {name=l1286 sig_type=std_logic lab=WL_10_I}
C {devices/lab_pin.sym} 880 2470 0 0 {name=l1287 sig_type=std_logic lab=PL_10_I}
C {devices/lab_pin.sym} 880 2530 0 0 {name=l1288 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 2500 0 0 {name=Xc_10_2
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 2470 0 0 {name=l1289 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 2530 0 0 {name=l1290 sig_type=std_logic lab=WL_10_I}
C {devices/lab_pin.sym} 1280 2470 0 0 {name=l1291 sig_type=std_logic lab=PL_10_I}
C {devices/lab_pin.sym} 1280 2530 0 0 {name=l1292 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 2500 0 0 {name=Xc_10_3
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 2470 0 0 {name=l1293 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 2530 0 0 {name=l1294 sig_type=std_logic lab=WL_10_I}
C {devices/lab_pin.sym} 1680 2470 0 0 {name=l1295 sig_type=std_logic lab=PL_10_I}
C {devices/lab_pin.sym} 1680 2530 0 0 {name=l1296 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 2500 0 0 {name=Xc_10_4
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 2470 0 0 {name=l1297 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 2530 0 0 {name=l1298 sig_type=std_logic lab=WL_10_I}
C {devices/lab_pin.sym} 2080 2470 0 0 {name=l1299 sig_type=std_logic lab=PL_10_I}
C {devices/lab_pin.sym} 2080 2530 0 0 {name=l1300 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 2500 0 0 {name=Xc_10_5
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 2470 0 0 {name=l1301 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 2530 0 0 {name=l1302 sig_type=std_logic lab=WL_10_I}
C {devices/lab_pin.sym} 2480 2470 0 0 {name=l1303 sig_type=std_logic lab=PL_10_I}
C {devices/lab_pin.sym} 2480 2530 0 0 {name=l1304 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 2500 0 0 {name=Xc_10_6
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 2470 0 0 {name=l1305 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 2530 0 0 {name=l1306 sig_type=std_logic lab=WL_10_I}
C {devices/lab_pin.sym} 2880 2470 0 0 {name=l1307 sig_type=std_logic lab=PL_10_I}
C {devices/lab_pin.sym} 2880 2530 0 0 {name=l1308 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 2500 0 0 {name=Xc_10_7
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 2470 0 0 {name=l1309 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 2530 0 0 {name=l1310 sig_type=std_logic lab=WL_10_I}
C {devices/lab_pin.sym} 3280 2470 0 0 {name=l1311 sig_type=std_logic lab=PL_10_I}
C {devices/lab_pin.sym} 3280 2530 0 0 {name=l1312 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 2500 0 0 {name=Xc_10_8
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 2470 0 0 {name=l1313 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 2530 0 0 {name=l1314 sig_type=std_logic lab=WL_10_I}
C {devices/lab_pin.sym} 3680 2470 0 0 {name=l1315 sig_type=std_logic lab=PL_10_I}
C {devices/lab_pin.sym} 3680 2530 0 0 {name=l1316 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 2500 0 0 {name=Xc_10_9
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 2470 0 0 {name=l1317 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 2530 0 0 {name=l1318 sig_type=std_logic lab=WL_10_I}
C {devices/lab_pin.sym} 4080 2470 0 0 {name=l1319 sig_type=std_logic lab=PL_10_I}
C {devices/lab_pin.sym} 4080 2530 0 0 {name=l1320 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 2500 0 0 {name=Xc_10_10
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 2470 0 0 {name=l1321 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 2530 0 0 {name=l1322 sig_type=std_logic lab=WL_10_I}
C {devices/lab_pin.sym} 4480 2470 0 0 {name=l1323 sig_type=std_logic lab=PL_10_I}
C {devices/lab_pin.sym} 4480 2530 0 0 {name=l1324 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 2500 0 0 {name=Xc_10_11
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 2470 0 0 {name=l1325 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 2530 0 0 {name=l1326 sig_type=std_logic lab=WL_10_II}
C {devices/lab_pin.sym} 4880 2470 0 0 {name=l1327 sig_type=std_logic lab=PL_10_II}
C {devices/lab_pin.sym} 4880 2530 0 0 {name=l1328 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 2500 0 0 {name=Xc_10_12
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 2470 0 0 {name=l1329 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 2530 0 0 {name=l1330 sig_type=std_logic lab=WL_10_II}
C {devices/lab_pin.sym} 5280 2470 0 0 {name=l1331 sig_type=std_logic lab=PL_10_II}
C {devices/lab_pin.sym} 5280 2530 0 0 {name=l1332 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 2500 0 0 {name=Xc_10_13
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 2470 0 0 {name=l1333 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 2530 0 0 {name=l1334 sig_type=std_logic lab=WL_10_II}
C {devices/lab_pin.sym} 5680 2470 0 0 {name=l1335 sig_type=std_logic lab=PL_10_II}
C {devices/lab_pin.sym} 5680 2530 0 0 {name=l1336 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 2500 0 0 {name=Xc_10_14
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 2470 0 0 {name=l1337 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 2530 0 0 {name=l1338 sig_type=std_logic lab=WL_10_II}
C {devices/lab_pin.sym} 6080 2470 0 0 {name=l1339 sig_type=std_logic lab=PL_10_II}
C {devices/lab_pin.sym} 6080 2530 0 0 {name=l1340 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 2500 0 0 {name=Xc_10_15
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 2470 0 0 {name=l1341 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 2530 0 0 {name=l1342 sig_type=std_logic lab=WL_10_II}
C {devices/lab_pin.sym} 6480 2470 0 0 {name=l1343 sig_type=std_logic lab=PL_10_II}
C {devices/lab_pin.sym} 6480 2530 0 0 {name=l1344 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 2500 0 0 {name=Xc_10_16
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 2470 0 0 {name=l1345 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 2530 0 0 {name=l1346 sig_type=std_logic lab=WL_10_II}
C {devices/lab_pin.sym} 6880 2470 0 0 {name=l1347 sig_type=std_logic lab=PL_10_II}
C {devices/lab_pin.sym} 6880 2530 0 0 {name=l1348 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 2500 0 0 {name=Xc_10_17
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 2470 0 0 {name=l1349 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 2530 0 0 {name=l1350 sig_type=std_logic lab=WL_10_II}
C {devices/lab_pin.sym} 7280 2470 0 0 {name=l1351 sig_type=std_logic lab=PL_10_II}
C {devices/lab_pin.sym} 7280 2530 0 0 {name=l1352 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 2500 0 0 {name=Xc_10_18
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 2470 0 0 {name=l1353 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 2530 0 0 {name=l1354 sig_type=std_logic lab=WL_10_II}
C {devices/lab_pin.sym} 7680 2470 0 0 {name=l1355 sig_type=std_logic lab=PL_10_II}
C {devices/lab_pin.sym} 7680 2530 0 0 {name=l1356 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 2500 0 0 {name=Xc_10_19
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 2470 0 0 {name=l1357 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 2530 0 0 {name=l1358 sig_type=std_logic lab=WL_10_II}
C {devices/lab_pin.sym} 8080 2470 0 0 {name=l1359 sig_type=std_logic lab=PL_10_II}
C {devices/lab_pin.sym} 8080 2530 0 0 {name=l1360 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 2500 0 0 {name=Xc_10_20
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 2470 0 0 {name=l1361 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 2530 0 0 {name=l1362 sig_type=std_logic lab=WL_10_II}
C {devices/lab_pin.sym} 8480 2470 0 0 {name=l1363 sig_type=std_logic lab=PL_10_II}
C {devices/lab_pin.sym} 8480 2530 0 0 {name=l1364 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 2500 0 0 {name=Xc_10_21
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 2470 0 0 {name=l1365 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 2530 0 0 {name=l1366 sig_type=std_logic lab=WL_10_II}
C {devices/lab_pin.sym} 8880 2470 0 0 {name=l1367 sig_type=std_logic lab=PL_10_II}
C {devices/lab_pin.sym} 8880 2530 0 0 {name=l1368 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 2500 0 0 {name=Xc_10_22
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 2470 0 0 {name=l1369 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 2530 0 0 {name=l1370 sig_type=std_logic lab=WL_10_III}
C {devices/lab_pin.sym} 9280 2470 0 0 {name=l1371 sig_type=std_logic lab=PL_10_III}
C {devices/lab_pin.sym} 9280 2530 0 0 {name=l1372 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 2500 0 0 {name=Xc_10_23
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 2470 0 0 {name=l1373 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 2530 0 0 {name=l1374 sig_type=std_logic lab=WL_10_III}
C {devices/lab_pin.sym} 9680 2470 0 0 {name=l1375 sig_type=std_logic lab=PL_10_III}
C {devices/lab_pin.sym} 9680 2530 0 0 {name=l1376 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 2500 0 0 {name=Xc_10_24
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 2470 0 0 {name=l1377 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 2530 0 0 {name=l1378 sig_type=std_logic lab=WL_10_III}
C {devices/lab_pin.sym} 10080 2470 0 0 {name=l1379 sig_type=std_logic lab=PL_10_III}
C {devices/lab_pin.sym} 10080 2530 0 0 {name=l1380 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 2500 0 0 {name=Xc_10_25
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 2470 0 0 {name=l1381 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 2530 0 0 {name=l1382 sig_type=std_logic lab=WL_10_III}
C {devices/lab_pin.sym} 10480 2470 0 0 {name=l1383 sig_type=std_logic lab=PL_10_III}
C {devices/lab_pin.sym} 10480 2530 0 0 {name=l1384 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 2500 0 0 {name=Xc_10_26
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 2470 0 0 {name=l1385 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 2530 0 0 {name=l1386 sig_type=std_logic lab=WL_10_III}
C {devices/lab_pin.sym} 10880 2470 0 0 {name=l1387 sig_type=std_logic lab=PL_10_III}
C {devices/lab_pin.sym} 10880 2530 0 0 {name=l1388 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 2500 0 0 {name=Xc_10_27
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 2470 0 0 {name=l1389 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 2530 0 0 {name=l1390 sig_type=std_logic lab=WL_10_III}
C {devices/lab_pin.sym} 11280 2470 0 0 {name=l1391 sig_type=std_logic lab=PL_10_III}
C {devices/lab_pin.sym} 11280 2530 0 0 {name=l1392 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 2500 0 0 {name=Xc_10_28
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 2470 0 0 {name=l1393 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 2530 0 0 {name=l1394 sig_type=std_logic lab=WL_10_III}
C {devices/lab_pin.sym} 11680 2470 0 0 {name=l1395 sig_type=std_logic lab=PL_10_III}
C {devices/lab_pin.sym} 11680 2530 0 0 {name=l1396 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 2500 0 0 {name=Xc_10_29
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 2470 0 0 {name=l1397 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 2530 0 0 {name=l1398 sig_type=std_logic lab=WL_10_III}
C {devices/lab_pin.sym} 12080 2470 0 0 {name=l1399 sig_type=std_logic lab=PL_10_III}
C {devices/lab_pin.sym} 12080 2530 0 0 {name=l1400 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 2500 0 0 {name=Xc_10_30
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 2470 0 0 {name=l1401 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 2530 0 0 {name=l1402 sig_type=std_logic lab=WL_10_III}
C {devices/lab_pin.sym} 12480 2470 0 0 {name=l1403 sig_type=std_logic lab=PL_10_III}
C {devices/lab_pin.sym} 12480 2530 0 0 {name=l1404 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 2500 0 0 {name=Xc_10_31
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 2470 0 0 {name=l1405 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 2530 0 0 {name=l1406 sig_type=std_logic lab=WL_10_III}
C {devices/lab_pin.sym} 12880 2470 0 0 {name=l1407 sig_type=std_logic lab=PL_10_III}
C {devices/lab_pin.sym} 12880 2530 0 0 {name=l1408 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 2720 0 0 {name=Xc_11_0
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 2690 0 0 {name=l1409 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 2750 0 0 {name=l1410 sig_type=std_logic lab=WL_11_I}
C {devices/lab_pin.sym} 480 2690 0 0 {name=l1411 sig_type=std_logic lab=PL_11_I}
C {devices/lab_pin.sym} 480 2750 0 0 {name=l1412 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 2720 0 0 {name=Xc_11_1
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 2690 0 0 {name=l1413 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 2750 0 0 {name=l1414 sig_type=std_logic lab=WL_11_I}
C {devices/lab_pin.sym} 880 2690 0 0 {name=l1415 sig_type=std_logic lab=PL_11_I}
C {devices/lab_pin.sym} 880 2750 0 0 {name=l1416 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 2720 0 0 {name=Xc_11_2
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 2690 0 0 {name=l1417 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 2750 0 0 {name=l1418 sig_type=std_logic lab=WL_11_I}
C {devices/lab_pin.sym} 1280 2690 0 0 {name=l1419 sig_type=std_logic lab=PL_11_I}
C {devices/lab_pin.sym} 1280 2750 0 0 {name=l1420 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 2720 0 0 {name=Xc_11_3
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 2690 0 0 {name=l1421 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 2750 0 0 {name=l1422 sig_type=std_logic lab=WL_11_I}
C {devices/lab_pin.sym} 1680 2690 0 0 {name=l1423 sig_type=std_logic lab=PL_11_I}
C {devices/lab_pin.sym} 1680 2750 0 0 {name=l1424 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 2720 0 0 {name=Xc_11_4
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 2690 0 0 {name=l1425 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 2750 0 0 {name=l1426 sig_type=std_logic lab=WL_11_I}
C {devices/lab_pin.sym} 2080 2690 0 0 {name=l1427 sig_type=std_logic lab=PL_11_I}
C {devices/lab_pin.sym} 2080 2750 0 0 {name=l1428 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 2720 0 0 {name=Xc_11_5
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 2690 0 0 {name=l1429 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 2750 0 0 {name=l1430 sig_type=std_logic lab=WL_11_I}
C {devices/lab_pin.sym} 2480 2690 0 0 {name=l1431 sig_type=std_logic lab=PL_11_I}
C {devices/lab_pin.sym} 2480 2750 0 0 {name=l1432 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 2720 0 0 {name=Xc_11_6
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 2690 0 0 {name=l1433 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 2750 0 0 {name=l1434 sig_type=std_logic lab=WL_11_I}
C {devices/lab_pin.sym} 2880 2690 0 0 {name=l1435 sig_type=std_logic lab=PL_11_I}
C {devices/lab_pin.sym} 2880 2750 0 0 {name=l1436 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 2720 0 0 {name=Xc_11_7
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 2690 0 0 {name=l1437 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 2750 0 0 {name=l1438 sig_type=std_logic lab=WL_11_I}
C {devices/lab_pin.sym} 3280 2690 0 0 {name=l1439 sig_type=std_logic lab=PL_11_I}
C {devices/lab_pin.sym} 3280 2750 0 0 {name=l1440 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 2720 0 0 {name=Xc_11_8
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 2690 0 0 {name=l1441 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 2750 0 0 {name=l1442 sig_type=std_logic lab=WL_11_I}
C {devices/lab_pin.sym} 3680 2690 0 0 {name=l1443 sig_type=std_logic lab=PL_11_I}
C {devices/lab_pin.sym} 3680 2750 0 0 {name=l1444 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 2720 0 0 {name=Xc_11_9
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 2690 0 0 {name=l1445 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 2750 0 0 {name=l1446 sig_type=std_logic lab=WL_11_I}
C {devices/lab_pin.sym} 4080 2690 0 0 {name=l1447 sig_type=std_logic lab=PL_11_I}
C {devices/lab_pin.sym} 4080 2750 0 0 {name=l1448 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 2720 0 0 {name=Xc_11_10
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 2690 0 0 {name=l1449 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 2750 0 0 {name=l1450 sig_type=std_logic lab=WL_11_I}
C {devices/lab_pin.sym} 4480 2690 0 0 {name=l1451 sig_type=std_logic lab=PL_11_I}
C {devices/lab_pin.sym} 4480 2750 0 0 {name=l1452 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 2720 0 0 {name=Xc_11_11
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 2690 0 0 {name=l1453 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 2750 0 0 {name=l1454 sig_type=std_logic lab=WL_11_II}
C {devices/lab_pin.sym} 4880 2690 0 0 {name=l1455 sig_type=std_logic lab=PL_11_II}
C {devices/lab_pin.sym} 4880 2750 0 0 {name=l1456 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 2720 0 0 {name=Xc_11_12
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 2690 0 0 {name=l1457 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 2750 0 0 {name=l1458 sig_type=std_logic lab=WL_11_II}
C {devices/lab_pin.sym} 5280 2690 0 0 {name=l1459 sig_type=std_logic lab=PL_11_II}
C {devices/lab_pin.sym} 5280 2750 0 0 {name=l1460 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 2720 0 0 {name=Xc_11_13
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 2690 0 0 {name=l1461 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 2750 0 0 {name=l1462 sig_type=std_logic lab=WL_11_II}
C {devices/lab_pin.sym} 5680 2690 0 0 {name=l1463 sig_type=std_logic lab=PL_11_II}
C {devices/lab_pin.sym} 5680 2750 0 0 {name=l1464 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 2720 0 0 {name=Xc_11_14
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 2690 0 0 {name=l1465 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 2750 0 0 {name=l1466 sig_type=std_logic lab=WL_11_II}
C {devices/lab_pin.sym} 6080 2690 0 0 {name=l1467 sig_type=std_logic lab=PL_11_II}
C {devices/lab_pin.sym} 6080 2750 0 0 {name=l1468 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 2720 0 0 {name=Xc_11_15
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 2690 0 0 {name=l1469 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 2750 0 0 {name=l1470 sig_type=std_logic lab=WL_11_II}
C {devices/lab_pin.sym} 6480 2690 0 0 {name=l1471 sig_type=std_logic lab=PL_11_II}
C {devices/lab_pin.sym} 6480 2750 0 0 {name=l1472 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 2720 0 0 {name=Xc_11_16
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 2690 0 0 {name=l1473 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 2750 0 0 {name=l1474 sig_type=std_logic lab=WL_11_II}
C {devices/lab_pin.sym} 6880 2690 0 0 {name=l1475 sig_type=std_logic lab=PL_11_II}
C {devices/lab_pin.sym} 6880 2750 0 0 {name=l1476 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 2720 0 0 {name=Xc_11_17
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 2690 0 0 {name=l1477 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 2750 0 0 {name=l1478 sig_type=std_logic lab=WL_11_II}
C {devices/lab_pin.sym} 7280 2690 0 0 {name=l1479 sig_type=std_logic lab=PL_11_II}
C {devices/lab_pin.sym} 7280 2750 0 0 {name=l1480 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 2720 0 0 {name=Xc_11_18
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 2690 0 0 {name=l1481 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 2750 0 0 {name=l1482 sig_type=std_logic lab=WL_11_II}
C {devices/lab_pin.sym} 7680 2690 0 0 {name=l1483 sig_type=std_logic lab=PL_11_II}
C {devices/lab_pin.sym} 7680 2750 0 0 {name=l1484 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 2720 0 0 {name=Xc_11_19
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 2690 0 0 {name=l1485 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 2750 0 0 {name=l1486 sig_type=std_logic lab=WL_11_II}
C {devices/lab_pin.sym} 8080 2690 0 0 {name=l1487 sig_type=std_logic lab=PL_11_II}
C {devices/lab_pin.sym} 8080 2750 0 0 {name=l1488 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 2720 0 0 {name=Xc_11_20
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 2690 0 0 {name=l1489 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 2750 0 0 {name=l1490 sig_type=std_logic lab=WL_11_II}
C {devices/lab_pin.sym} 8480 2690 0 0 {name=l1491 sig_type=std_logic lab=PL_11_II}
C {devices/lab_pin.sym} 8480 2750 0 0 {name=l1492 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 2720 0 0 {name=Xc_11_21
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 2690 0 0 {name=l1493 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 2750 0 0 {name=l1494 sig_type=std_logic lab=WL_11_II}
C {devices/lab_pin.sym} 8880 2690 0 0 {name=l1495 sig_type=std_logic lab=PL_11_II}
C {devices/lab_pin.sym} 8880 2750 0 0 {name=l1496 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 2720 0 0 {name=Xc_11_22
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 2690 0 0 {name=l1497 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 2750 0 0 {name=l1498 sig_type=std_logic lab=WL_11_III}
C {devices/lab_pin.sym} 9280 2690 0 0 {name=l1499 sig_type=std_logic lab=PL_11_III}
C {devices/lab_pin.sym} 9280 2750 0 0 {name=l1500 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 2720 0 0 {name=Xc_11_23
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 2690 0 0 {name=l1501 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 2750 0 0 {name=l1502 sig_type=std_logic lab=WL_11_III}
C {devices/lab_pin.sym} 9680 2690 0 0 {name=l1503 sig_type=std_logic lab=PL_11_III}
C {devices/lab_pin.sym} 9680 2750 0 0 {name=l1504 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 2720 0 0 {name=Xc_11_24
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 2690 0 0 {name=l1505 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 2750 0 0 {name=l1506 sig_type=std_logic lab=WL_11_III}
C {devices/lab_pin.sym} 10080 2690 0 0 {name=l1507 sig_type=std_logic lab=PL_11_III}
C {devices/lab_pin.sym} 10080 2750 0 0 {name=l1508 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 2720 0 0 {name=Xc_11_25
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 2690 0 0 {name=l1509 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 2750 0 0 {name=l1510 sig_type=std_logic lab=WL_11_III}
C {devices/lab_pin.sym} 10480 2690 0 0 {name=l1511 sig_type=std_logic lab=PL_11_III}
C {devices/lab_pin.sym} 10480 2750 0 0 {name=l1512 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 2720 0 0 {name=Xc_11_26
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 2690 0 0 {name=l1513 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 2750 0 0 {name=l1514 sig_type=std_logic lab=WL_11_III}
C {devices/lab_pin.sym} 10880 2690 0 0 {name=l1515 sig_type=std_logic lab=PL_11_III}
C {devices/lab_pin.sym} 10880 2750 0 0 {name=l1516 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 2720 0 0 {name=Xc_11_27
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 2690 0 0 {name=l1517 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 2750 0 0 {name=l1518 sig_type=std_logic lab=WL_11_III}
C {devices/lab_pin.sym} 11280 2690 0 0 {name=l1519 sig_type=std_logic lab=PL_11_III}
C {devices/lab_pin.sym} 11280 2750 0 0 {name=l1520 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 2720 0 0 {name=Xc_11_28
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 2690 0 0 {name=l1521 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 2750 0 0 {name=l1522 sig_type=std_logic lab=WL_11_III}
C {devices/lab_pin.sym} 11680 2690 0 0 {name=l1523 sig_type=std_logic lab=PL_11_III}
C {devices/lab_pin.sym} 11680 2750 0 0 {name=l1524 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 2720 0 0 {name=Xc_11_29
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 2690 0 0 {name=l1525 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 2750 0 0 {name=l1526 sig_type=std_logic lab=WL_11_III}
C {devices/lab_pin.sym} 12080 2690 0 0 {name=l1527 sig_type=std_logic lab=PL_11_III}
C {devices/lab_pin.sym} 12080 2750 0 0 {name=l1528 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 2720 0 0 {name=Xc_11_30
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 2690 0 0 {name=l1529 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 2750 0 0 {name=l1530 sig_type=std_logic lab=WL_11_III}
C {devices/lab_pin.sym} 12480 2690 0 0 {name=l1531 sig_type=std_logic lab=PL_11_III}
C {devices/lab_pin.sym} 12480 2750 0 0 {name=l1532 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 2720 0 0 {name=Xc_11_31
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 2690 0 0 {name=l1533 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 2750 0 0 {name=l1534 sig_type=std_logic lab=WL_11_III}
C {devices/lab_pin.sym} 12880 2690 0 0 {name=l1535 sig_type=std_logic lab=PL_11_III}
C {devices/lab_pin.sym} 12880 2750 0 0 {name=l1536 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 2940 0 0 {name=Xc_12_0
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 2910 0 0 {name=l1537 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 2970 0 0 {name=l1538 sig_type=std_logic lab=WL_12_I}
C {devices/lab_pin.sym} 480 2910 0 0 {name=l1539 sig_type=std_logic lab=PL_12_I}
C {devices/lab_pin.sym} 480 2970 0 0 {name=l1540 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 2940 0 0 {name=Xc_12_1
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 2910 0 0 {name=l1541 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 2970 0 0 {name=l1542 sig_type=std_logic lab=WL_12_I}
C {devices/lab_pin.sym} 880 2910 0 0 {name=l1543 sig_type=std_logic lab=PL_12_I}
C {devices/lab_pin.sym} 880 2970 0 0 {name=l1544 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 2940 0 0 {name=Xc_12_2
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 2910 0 0 {name=l1545 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 2970 0 0 {name=l1546 sig_type=std_logic lab=WL_12_I}
C {devices/lab_pin.sym} 1280 2910 0 0 {name=l1547 sig_type=std_logic lab=PL_12_I}
C {devices/lab_pin.sym} 1280 2970 0 0 {name=l1548 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 2940 0 0 {name=Xc_12_3
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 2910 0 0 {name=l1549 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 2970 0 0 {name=l1550 sig_type=std_logic lab=WL_12_I}
C {devices/lab_pin.sym} 1680 2910 0 0 {name=l1551 sig_type=std_logic lab=PL_12_I}
C {devices/lab_pin.sym} 1680 2970 0 0 {name=l1552 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 2940 0 0 {name=Xc_12_4
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 2910 0 0 {name=l1553 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 2970 0 0 {name=l1554 sig_type=std_logic lab=WL_12_I}
C {devices/lab_pin.sym} 2080 2910 0 0 {name=l1555 sig_type=std_logic lab=PL_12_I}
C {devices/lab_pin.sym} 2080 2970 0 0 {name=l1556 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 2940 0 0 {name=Xc_12_5
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 2910 0 0 {name=l1557 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 2970 0 0 {name=l1558 sig_type=std_logic lab=WL_12_I}
C {devices/lab_pin.sym} 2480 2910 0 0 {name=l1559 sig_type=std_logic lab=PL_12_I}
C {devices/lab_pin.sym} 2480 2970 0 0 {name=l1560 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 2940 0 0 {name=Xc_12_6
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 2910 0 0 {name=l1561 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 2970 0 0 {name=l1562 sig_type=std_logic lab=WL_12_I}
C {devices/lab_pin.sym} 2880 2910 0 0 {name=l1563 sig_type=std_logic lab=PL_12_I}
C {devices/lab_pin.sym} 2880 2970 0 0 {name=l1564 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 2940 0 0 {name=Xc_12_7
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 2910 0 0 {name=l1565 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 2970 0 0 {name=l1566 sig_type=std_logic lab=WL_12_I}
C {devices/lab_pin.sym} 3280 2910 0 0 {name=l1567 sig_type=std_logic lab=PL_12_I}
C {devices/lab_pin.sym} 3280 2970 0 0 {name=l1568 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 2940 0 0 {name=Xc_12_8
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 2910 0 0 {name=l1569 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 2970 0 0 {name=l1570 sig_type=std_logic lab=WL_12_I}
C {devices/lab_pin.sym} 3680 2910 0 0 {name=l1571 sig_type=std_logic lab=PL_12_I}
C {devices/lab_pin.sym} 3680 2970 0 0 {name=l1572 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 2940 0 0 {name=Xc_12_9
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 2910 0 0 {name=l1573 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 2970 0 0 {name=l1574 sig_type=std_logic lab=WL_12_I}
C {devices/lab_pin.sym} 4080 2910 0 0 {name=l1575 sig_type=std_logic lab=PL_12_I}
C {devices/lab_pin.sym} 4080 2970 0 0 {name=l1576 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 2940 0 0 {name=Xc_12_10
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 2910 0 0 {name=l1577 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 2970 0 0 {name=l1578 sig_type=std_logic lab=WL_12_I}
C {devices/lab_pin.sym} 4480 2910 0 0 {name=l1579 sig_type=std_logic lab=PL_12_I}
C {devices/lab_pin.sym} 4480 2970 0 0 {name=l1580 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 2940 0 0 {name=Xc_12_11
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 2910 0 0 {name=l1581 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 2970 0 0 {name=l1582 sig_type=std_logic lab=WL_12_II}
C {devices/lab_pin.sym} 4880 2910 0 0 {name=l1583 sig_type=std_logic lab=PL_12_II}
C {devices/lab_pin.sym} 4880 2970 0 0 {name=l1584 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 2940 0 0 {name=Xc_12_12
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 2910 0 0 {name=l1585 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 2970 0 0 {name=l1586 sig_type=std_logic lab=WL_12_II}
C {devices/lab_pin.sym} 5280 2910 0 0 {name=l1587 sig_type=std_logic lab=PL_12_II}
C {devices/lab_pin.sym} 5280 2970 0 0 {name=l1588 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 2940 0 0 {name=Xc_12_13
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 2910 0 0 {name=l1589 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 2970 0 0 {name=l1590 sig_type=std_logic lab=WL_12_II}
C {devices/lab_pin.sym} 5680 2910 0 0 {name=l1591 sig_type=std_logic lab=PL_12_II}
C {devices/lab_pin.sym} 5680 2970 0 0 {name=l1592 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 2940 0 0 {name=Xc_12_14
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 2910 0 0 {name=l1593 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 2970 0 0 {name=l1594 sig_type=std_logic lab=WL_12_II}
C {devices/lab_pin.sym} 6080 2910 0 0 {name=l1595 sig_type=std_logic lab=PL_12_II}
C {devices/lab_pin.sym} 6080 2970 0 0 {name=l1596 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 2940 0 0 {name=Xc_12_15
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 2910 0 0 {name=l1597 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 2970 0 0 {name=l1598 sig_type=std_logic lab=WL_12_II}
C {devices/lab_pin.sym} 6480 2910 0 0 {name=l1599 sig_type=std_logic lab=PL_12_II}
C {devices/lab_pin.sym} 6480 2970 0 0 {name=l1600 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 2940 0 0 {name=Xc_12_16
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 2910 0 0 {name=l1601 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 2970 0 0 {name=l1602 sig_type=std_logic lab=WL_12_II}
C {devices/lab_pin.sym} 6880 2910 0 0 {name=l1603 sig_type=std_logic lab=PL_12_II}
C {devices/lab_pin.sym} 6880 2970 0 0 {name=l1604 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 2940 0 0 {name=Xc_12_17
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 2910 0 0 {name=l1605 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 2970 0 0 {name=l1606 sig_type=std_logic lab=WL_12_II}
C {devices/lab_pin.sym} 7280 2910 0 0 {name=l1607 sig_type=std_logic lab=PL_12_II}
C {devices/lab_pin.sym} 7280 2970 0 0 {name=l1608 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 2940 0 0 {name=Xc_12_18
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 2910 0 0 {name=l1609 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 2970 0 0 {name=l1610 sig_type=std_logic lab=WL_12_II}
C {devices/lab_pin.sym} 7680 2910 0 0 {name=l1611 sig_type=std_logic lab=PL_12_II}
C {devices/lab_pin.sym} 7680 2970 0 0 {name=l1612 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 2940 0 0 {name=Xc_12_19
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 2910 0 0 {name=l1613 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 2970 0 0 {name=l1614 sig_type=std_logic lab=WL_12_II}
C {devices/lab_pin.sym} 8080 2910 0 0 {name=l1615 sig_type=std_logic lab=PL_12_II}
C {devices/lab_pin.sym} 8080 2970 0 0 {name=l1616 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 2940 0 0 {name=Xc_12_20
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 2910 0 0 {name=l1617 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 2970 0 0 {name=l1618 sig_type=std_logic lab=WL_12_II}
C {devices/lab_pin.sym} 8480 2910 0 0 {name=l1619 sig_type=std_logic lab=PL_12_II}
C {devices/lab_pin.sym} 8480 2970 0 0 {name=l1620 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 2940 0 0 {name=Xc_12_21
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 2910 0 0 {name=l1621 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 2970 0 0 {name=l1622 sig_type=std_logic lab=WL_12_II}
C {devices/lab_pin.sym} 8880 2910 0 0 {name=l1623 sig_type=std_logic lab=PL_12_II}
C {devices/lab_pin.sym} 8880 2970 0 0 {name=l1624 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 2940 0 0 {name=Xc_12_22
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 2910 0 0 {name=l1625 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 2970 0 0 {name=l1626 sig_type=std_logic lab=WL_12_III}
C {devices/lab_pin.sym} 9280 2910 0 0 {name=l1627 sig_type=std_logic lab=PL_12_III}
C {devices/lab_pin.sym} 9280 2970 0 0 {name=l1628 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 2940 0 0 {name=Xc_12_23
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 2910 0 0 {name=l1629 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 2970 0 0 {name=l1630 sig_type=std_logic lab=WL_12_III}
C {devices/lab_pin.sym} 9680 2910 0 0 {name=l1631 sig_type=std_logic lab=PL_12_III}
C {devices/lab_pin.sym} 9680 2970 0 0 {name=l1632 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 2940 0 0 {name=Xc_12_24
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 2910 0 0 {name=l1633 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 2970 0 0 {name=l1634 sig_type=std_logic lab=WL_12_III}
C {devices/lab_pin.sym} 10080 2910 0 0 {name=l1635 sig_type=std_logic lab=PL_12_III}
C {devices/lab_pin.sym} 10080 2970 0 0 {name=l1636 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 2940 0 0 {name=Xc_12_25
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 2910 0 0 {name=l1637 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 2970 0 0 {name=l1638 sig_type=std_logic lab=WL_12_III}
C {devices/lab_pin.sym} 10480 2910 0 0 {name=l1639 sig_type=std_logic lab=PL_12_III}
C {devices/lab_pin.sym} 10480 2970 0 0 {name=l1640 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 2940 0 0 {name=Xc_12_26
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 2910 0 0 {name=l1641 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 2970 0 0 {name=l1642 sig_type=std_logic lab=WL_12_III}
C {devices/lab_pin.sym} 10880 2910 0 0 {name=l1643 sig_type=std_logic lab=PL_12_III}
C {devices/lab_pin.sym} 10880 2970 0 0 {name=l1644 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 2940 0 0 {name=Xc_12_27
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 2910 0 0 {name=l1645 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 2970 0 0 {name=l1646 sig_type=std_logic lab=WL_12_III}
C {devices/lab_pin.sym} 11280 2910 0 0 {name=l1647 sig_type=std_logic lab=PL_12_III}
C {devices/lab_pin.sym} 11280 2970 0 0 {name=l1648 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 2940 0 0 {name=Xc_12_28
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 2910 0 0 {name=l1649 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 2970 0 0 {name=l1650 sig_type=std_logic lab=WL_12_III}
C {devices/lab_pin.sym} 11680 2910 0 0 {name=l1651 sig_type=std_logic lab=PL_12_III}
C {devices/lab_pin.sym} 11680 2970 0 0 {name=l1652 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 2940 0 0 {name=Xc_12_29
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 2910 0 0 {name=l1653 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 2970 0 0 {name=l1654 sig_type=std_logic lab=WL_12_III}
C {devices/lab_pin.sym} 12080 2910 0 0 {name=l1655 sig_type=std_logic lab=PL_12_III}
C {devices/lab_pin.sym} 12080 2970 0 0 {name=l1656 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 2940 0 0 {name=Xc_12_30
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 2910 0 0 {name=l1657 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 2970 0 0 {name=l1658 sig_type=std_logic lab=WL_12_III}
C {devices/lab_pin.sym} 12480 2910 0 0 {name=l1659 sig_type=std_logic lab=PL_12_III}
C {devices/lab_pin.sym} 12480 2970 0 0 {name=l1660 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 2940 0 0 {name=Xc_12_31
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 2910 0 0 {name=l1661 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 2970 0 0 {name=l1662 sig_type=std_logic lab=WL_12_III}
C {devices/lab_pin.sym} 12880 2910 0 0 {name=l1663 sig_type=std_logic lab=PL_12_III}
C {devices/lab_pin.sym} 12880 2970 0 0 {name=l1664 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 3160 0 0 {name=Xc_13_0
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 3130 0 0 {name=l1665 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 3190 0 0 {name=l1666 sig_type=std_logic lab=WL_13_I}
C {devices/lab_pin.sym} 480 3130 0 0 {name=l1667 sig_type=std_logic lab=PL_13_I}
C {devices/lab_pin.sym} 480 3190 0 0 {name=l1668 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 3160 0 0 {name=Xc_13_1
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 3130 0 0 {name=l1669 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 3190 0 0 {name=l1670 sig_type=std_logic lab=WL_13_I}
C {devices/lab_pin.sym} 880 3130 0 0 {name=l1671 sig_type=std_logic lab=PL_13_I}
C {devices/lab_pin.sym} 880 3190 0 0 {name=l1672 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 3160 0 0 {name=Xc_13_2
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 3130 0 0 {name=l1673 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 3190 0 0 {name=l1674 sig_type=std_logic lab=WL_13_I}
C {devices/lab_pin.sym} 1280 3130 0 0 {name=l1675 sig_type=std_logic lab=PL_13_I}
C {devices/lab_pin.sym} 1280 3190 0 0 {name=l1676 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 3160 0 0 {name=Xc_13_3
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 3130 0 0 {name=l1677 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 3190 0 0 {name=l1678 sig_type=std_logic lab=WL_13_I}
C {devices/lab_pin.sym} 1680 3130 0 0 {name=l1679 sig_type=std_logic lab=PL_13_I}
C {devices/lab_pin.sym} 1680 3190 0 0 {name=l1680 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 3160 0 0 {name=Xc_13_4
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 3130 0 0 {name=l1681 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 3190 0 0 {name=l1682 sig_type=std_logic lab=WL_13_I}
C {devices/lab_pin.sym} 2080 3130 0 0 {name=l1683 sig_type=std_logic lab=PL_13_I}
C {devices/lab_pin.sym} 2080 3190 0 0 {name=l1684 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 3160 0 0 {name=Xc_13_5
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 3130 0 0 {name=l1685 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 3190 0 0 {name=l1686 sig_type=std_logic lab=WL_13_I}
C {devices/lab_pin.sym} 2480 3130 0 0 {name=l1687 sig_type=std_logic lab=PL_13_I}
C {devices/lab_pin.sym} 2480 3190 0 0 {name=l1688 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 3160 0 0 {name=Xc_13_6
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 3130 0 0 {name=l1689 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 3190 0 0 {name=l1690 sig_type=std_logic lab=WL_13_I}
C {devices/lab_pin.sym} 2880 3130 0 0 {name=l1691 sig_type=std_logic lab=PL_13_I}
C {devices/lab_pin.sym} 2880 3190 0 0 {name=l1692 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 3160 0 0 {name=Xc_13_7
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 3130 0 0 {name=l1693 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 3190 0 0 {name=l1694 sig_type=std_logic lab=WL_13_I}
C {devices/lab_pin.sym} 3280 3130 0 0 {name=l1695 sig_type=std_logic lab=PL_13_I}
C {devices/lab_pin.sym} 3280 3190 0 0 {name=l1696 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 3160 0 0 {name=Xc_13_8
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 3130 0 0 {name=l1697 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 3190 0 0 {name=l1698 sig_type=std_logic lab=WL_13_I}
C {devices/lab_pin.sym} 3680 3130 0 0 {name=l1699 sig_type=std_logic lab=PL_13_I}
C {devices/lab_pin.sym} 3680 3190 0 0 {name=l1700 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 3160 0 0 {name=Xc_13_9
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 3130 0 0 {name=l1701 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 3190 0 0 {name=l1702 sig_type=std_logic lab=WL_13_I}
C {devices/lab_pin.sym} 4080 3130 0 0 {name=l1703 sig_type=std_logic lab=PL_13_I}
C {devices/lab_pin.sym} 4080 3190 0 0 {name=l1704 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 3160 0 0 {name=Xc_13_10
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 3130 0 0 {name=l1705 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 3190 0 0 {name=l1706 sig_type=std_logic lab=WL_13_I}
C {devices/lab_pin.sym} 4480 3130 0 0 {name=l1707 sig_type=std_logic lab=PL_13_I}
C {devices/lab_pin.sym} 4480 3190 0 0 {name=l1708 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 3160 0 0 {name=Xc_13_11
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 3130 0 0 {name=l1709 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 3190 0 0 {name=l1710 sig_type=std_logic lab=WL_13_II}
C {devices/lab_pin.sym} 4880 3130 0 0 {name=l1711 sig_type=std_logic lab=PL_13_II}
C {devices/lab_pin.sym} 4880 3190 0 0 {name=l1712 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 3160 0 0 {name=Xc_13_12
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 3130 0 0 {name=l1713 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 3190 0 0 {name=l1714 sig_type=std_logic lab=WL_13_II}
C {devices/lab_pin.sym} 5280 3130 0 0 {name=l1715 sig_type=std_logic lab=PL_13_II}
C {devices/lab_pin.sym} 5280 3190 0 0 {name=l1716 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 3160 0 0 {name=Xc_13_13
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 3130 0 0 {name=l1717 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 3190 0 0 {name=l1718 sig_type=std_logic lab=WL_13_II}
C {devices/lab_pin.sym} 5680 3130 0 0 {name=l1719 sig_type=std_logic lab=PL_13_II}
C {devices/lab_pin.sym} 5680 3190 0 0 {name=l1720 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 3160 0 0 {name=Xc_13_14
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 3130 0 0 {name=l1721 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 3190 0 0 {name=l1722 sig_type=std_logic lab=WL_13_II}
C {devices/lab_pin.sym} 6080 3130 0 0 {name=l1723 sig_type=std_logic lab=PL_13_II}
C {devices/lab_pin.sym} 6080 3190 0 0 {name=l1724 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 3160 0 0 {name=Xc_13_15
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 3130 0 0 {name=l1725 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 3190 0 0 {name=l1726 sig_type=std_logic lab=WL_13_II}
C {devices/lab_pin.sym} 6480 3130 0 0 {name=l1727 sig_type=std_logic lab=PL_13_II}
C {devices/lab_pin.sym} 6480 3190 0 0 {name=l1728 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 3160 0 0 {name=Xc_13_16
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 3130 0 0 {name=l1729 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 3190 0 0 {name=l1730 sig_type=std_logic lab=WL_13_II}
C {devices/lab_pin.sym} 6880 3130 0 0 {name=l1731 sig_type=std_logic lab=PL_13_II}
C {devices/lab_pin.sym} 6880 3190 0 0 {name=l1732 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 3160 0 0 {name=Xc_13_17
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 3130 0 0 {name=l1733 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 3190 0 0 {name=l1734 sig_type=std_logic lab=WL_13_II}
C {devices/lab_pin.sym} 7280 3130 0 0 {name=l1735 sig_type=std_logic lab=PL_13_II}
C {devices/lab_pin.sym} 7280 3190 0 0 {name=l1736 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 3160 0 0 {name=Xc_13_18
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 3130 0 0 {name=l1737 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 3190 0 0 {name=l1738 sig_type=std_logic lab=WL_13_II}
C {devices/lab_pin.sym} 7680 3130 0 0 {name=l1739 sig_type=std_logic lab=PL_13_II}
C {devices/lab_pin.sym} 7680 3190 0 0 {name=l1740 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 3160 0 0 {name=Xc_13_19
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 3130 0 0 {name=l1741 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 3190 0 0 {name=l1742 sig_type=std_logic lab=WL_13_II}
C {devices/lab_pin.sym} 8080 3130 0 0 {name=l1743 sig_type=std_logic lab=PL_13_II}
C {devices/lab_pin.sym} 8080 3190 0 0 {name=l1744 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 3160 0 0 {name=Xc_13_20
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 3130 0 0 {name=l1745 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 3190 0 0 {name=l1746 sig_type=std_logic lab=WL_13_II}
C {devices/lab_pin.sym} 8480 3130 0 0 {name=l1747 sig_type=std_logic lab=PL_13_II}
C {devices/lab_pin.sym} 8480 3190 0 0 {name=l1748 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 3160 0 0 {name=Xc_13_21
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 3130 0 0 {name=l1749 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 3190 0 0 {name=l1750 sig_type=std_logic lab=WL_13_II}
C {devices/lab_pin.sym} 8880 3130 0 0 {name=l1751 sig_type=std_logic lab=PL_13_II}
C {devices/lab_pin.sym} 8880 3190 0 0 {name=l1752 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 3160 0 0 {name=Xc_13_22
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 3130 0 0 {name=l1753 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 3190 0 0 {name=l1754 sig_type=std_logic lab=WL_13_III}
C {devices/lab_pin.sym} 9280 3130 0 0 {name=l1755 sig_type=std_logic lab=PL_13_III}
C {devices/lab_pin.sym} 9280 3190 0 0 {name=l1756 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 3160 0 0 {name=Xc_13_23
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 3130 0 0 {name=l1757 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 3190 0 0 {name=l1758 sig_type=std_logic lab=WL_13_III}
C {devices/lab_pin.sym} 9680 3130 0 0 {name=l1759 sig_type=std_logic lab=PL_13_III}
C {devices/lab_pin.sym} 9680 3190 0 0 {name=l1760 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 3160 0 0 {name=Xc_13_24
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 3130 0 0 {name=l1761 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 3190 0 0 {name=l1762 sig_type=std_logic lab=WL_13_III}
C {devices/lab_pin.sym} 10080 3130 0 0 {name=l1763 sig_type=std_logic lab=PL_13_III}
C {devices/lab_pin.sym} 10080 3190 0 0 {name=l1764 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 3160 0 0 {name=Xc_13_25
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 3130 0 0 {name=l1765 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 3190 0 0 {name=l1766 sig_type=std_logic lab=WL_13_III}
C {devices/lab_pin.sym} 10480 3130 0 0 {name=l1767 sig_type=std_logic lab=PL_13_III}
C {devices/lab_pin.sym} 10480 3190 0 0 {name=l1768 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 3160 0 0 {name=Xc_13_26
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 3130 0 0 {name=l1769 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 3190 0 0 {name=l1770 sig_type=std_logic lab=WL_13_III}
C {devices/lab_pin.sym} 10880 3130 0 0 {name=l1771 sig_type=std_logic lab=PL_13_III}
C {devices/lab_pin.sym} 10880 3190 0 0 {name=l1772 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 3160 0 0 {name=Xc_13_27
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 3130 0 0 {name=l1773 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 3190 0 0 {name=l1774 sig_type=std_logic lab=WL_13_III}
C {devices/lab_pin.sym} 11280 3130 0 0 {name=l1775 sig_type=std_logic lab=PL_13_III}
C {devices/lab_pin.sym} 11280 3190 0 0 {name=l1776 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 3160 0 0 {name=Xc_13_28
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 3130 0 0 {name=l1777 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 3190 0 0 {name=l1778 sig_type=std_logic lab=WL_13_III}
C {devices/lab_pin.sym} 11680 3130 0 0 {name=l1779 sig_type=std_logic lab=PL_13_III}
C {devices/lab_pin.sym} 11680 3190 0 0 {name=l1780 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 3160 0 0 {name=Xc_13_29
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 3130 0 0 {name=l1781 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 3190 0 0 {name=l1782 sig_type=std_logic lab=WL_13_III}
C {devices/lab_pin.sym} 12080 3130 0 0 {name=l1783 sig_type=std_logic lab=PL_13_III}
C {devices/lab_pin.sym} 12080 3190 0 0 {name=l1784 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 3160 0 0 {name=Xc_13_30
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 3130 0 0 {name=l1785 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 3190 0 0 {name=l1786 sig_type=std_logic lab=WL_13_III}
C {devices/lab_pin.sym} 12480 3130 0 0 {name=l1787 sig_type=std_logic lab=PL_13_III}
C {devices/lab_pin.sym} 12480 3190 0 0 {name=l1788 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 3160 0 0 {name=Xc_13_31
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 3130 0 0 {name=l1789 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 3190 0 0 {name=l1790 sig_type=std_logic lab=WL_13_III}
C {devices/lab_pin.sym} 12880 3130 0 0 {name=l1791 sig_type=std_logic lab=PL_13_III}
C {devices/lab_pin.sym} 12880 3190 0 0 {name=l1792 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 3380 0 0 {name=Xc_14_0
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 3350 0 0 {name=l1793 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 3410 0 0 {name=l1794 sig_type=std_logic lab=WL_14_I}
C {devices/lab_pin.sym} 480 3350 0 0 {name=l1795 sig_type=std_logic lab=PL_14_I}
C {devices/lab_pin.sym} 480 3410 0 0 {name=l1796 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 3380 0 0 {name=Xc_14_1
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 3350 0 0 {name=l1797 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 3410 0 0 {name=l1798 sig_type=std_logic lab=WL_14_I}
C {devices/lab_pin.sym} 880 3350 0 0 {name=l1799 sig_type=std_logic lab=PL_14_I}
C {devices/lab_pin.sym} 880 3410 0 0 {name=l1800 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 3380 0 0 {name=Xc_14_2
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 3350 0 0 {name=l1801 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 3410 0 0 {name=l1802 sig_type=std_logic lab=WL_14_I}
C {devices/lab_pin.sym} 1280 3350 0 0 {name=l1803 sig_type=std_logic lab=PL_14_I}
C {devices/lab_pin.sym} 1280 3410 0 0 {name=l1804 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 3380 0 0 {name=Xc_14_3
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 3350 0 0 {name=l1805 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 3410 0 0 {name=l1806 sig_type=std_logic lab=WL_14_I}
C {devices/lab_pin.sym} 1680 3350 0 0 {name=l1807 sig_type=std_logic lab=PL_14_I}
C {devices/lab_pin.sym} 1680 3410 0 0 {name=l1808 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 3380 0 0 {name=Xc_14_4
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 3350 0 0 {name=l1809 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 3410 0 0 {name=l1810 sig_type=std_logic lab=WL_14_I}
C {devices/lab_pin.sym} 2080 3350 0 0 {name=l1811 sig_type=std_logic lab=PL_14_I}
C {devices/lab_pin.sym} 2080 3410 0 0 {name=l1812 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 3380 0 0 {name=Xc_14_5
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 3350 0 0 {name=l1813 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 3410 0 0 {name=l1814 sig_type=std_logic lab=WL_14_I}
C {devices/lab_pin.sym} 2480 3350 0 0 {name=l1815 sig_type=std_logic lab=PL_14_I}
C {devices/lab_pin.sym} 2480 3410 0 0 {name=l1816 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 3380 0 0 {name=Xc_14_6
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 3350 0 0 {name=l1817 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 3410 0 0 {name=l1818 sig_type=std_logic lab=WL_14_I}
C {devices/lab_pin.sym} 2880 3350 0 0 {name=l1819 sig_type=std_logic lab=PL_14_I}
C {devices/lab_pin.sym} 2880 3410 0 0 {name=l1820 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 3380 0 0 {name=Xc_14_7
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 3350 0 0 {name=l1821 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 3410 0 0 {name=l1822 sig_type=std_logic lab=WL_14_I}
C {devices/lab_pin.sym} 3280 3350 0 0 {name=l1823 sig_type=std_logic lab=PL_14_I}
C {devices/lab_pin.sym} 3280 3410 0 0 {name=l1824 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 3380 0 0 {name=Xc_14_8
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 3350 0 0 {name=l1825 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 3410 0 0 {name=l1826 sig_type=std_logic lab=WL_14_I}
C {devices/lab_pin.sym} 3680 3350 0 0 {name=l1827 sig_type=std_logic lab=PL_14_I}
C {devices/lab_pin.sym} 3680 3410 0 0 {name=l1828 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 3380 0 0 {name=Xc_14_9
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 3350 0 0 {name=l1829 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 3410 0 0 {name=l1830 sig_type=std_logic lab=WL_14_I}
C {devices/lab_pin.sym} 4080 3350 0 0 {name=l1831 sig_type=std_logic lab=PL_14_I}
C {devices/lab_pin.sym} 4080 3410 0 0 {name=l1832 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 3380 0 0 {name=Xc_14_10
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 3350 0 0 {name=l1833 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 3410 0 0 {name=l1834 sig_type=std_logic lab=WL_14_I}
C {devices/lab_pin.sym} 4480 3350 0 0 {name=l1835 sig_type=std_logic lab=PL_14_I}
C {devices/lab_pin.sym} 4480 3410 0 0 {name=l1836 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 3380 0 0 {name=Xc_14_11
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 3350 0 0 {name=l1837 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 3410 0 0 {name=l1838 sig_type=std_logic lab=WL_14_II}
C {devices/lab_pin.sym} 4880 3350 0 0 {name=l1839 sig_type=std_logic lab=PL_14_II}
C {devices/lab_pin.sym} 4880 3410 0 0 {name=l1840 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 3380 0 0 {name=Xc_14_12
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 3350 0 0 {name=l1841 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 3410 0 0 {name=l1842 sig_type=std_logic lab=WL_14_II}
C {devices/lab_pin.sym} 5280 3350 0 0 {name=l1843 sig_type=std_logic lab=PL_14_II}
C {devices/lab_pin.sym} 5280 3410 0 0 {name=l1844 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 3380 0 0 {name=Xc_14_13
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 3350 0 0 {name=l1845 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 3410 0 0 {name=l1846 sig_type=std_logic lab=WL_14_II}
C {devices/lab_pin.sym} 5680 3350 0 0 {name=l1847 sig_type=std_logic lab=PL_14_II}
C {devices/lab_pin.sym} 5680 3410 0 0 {name=l1848 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 3380 0 0 {name=Xc_14_14
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 3350 0 0 {name=l1849 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 3410 0 0 {name=l1850 sig_type=std_logic lab=WL_14_II}
C {devices/lab_pin.sym} 6080 3350 0 0 {name=l1851 sig_type=std_logic lab=PL_14_II}
C {devices/lab_pin.sym} 6080 3410 0 0 {name=l1852 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 3380 0 0 {name=Xc_14_15
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 3350 0 0 {name=l1853 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 3410 0 0 {name=l1854 sig_type=std_logic lab=WL_14_II}
C {devices/lab_pin.sym} 6480 3350 0 0 {name=l1855 sig_type=std_logic lab=PL_14_II}
C {devices/lab_pin.sym} 6480 3410 0 0 {name=l1856 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 3380 0 0 {name=Xc_14_16
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 3350 0 0 {name=l1857 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 3410 0 0 {name=l1858 sig_type=std_logic lab=WL_14_II}
C {devices/lab_pin.sym} 6880 3350 0 0 {name=l1859 sig_type=std_logic lab=PL_14_II}
C {devices/lab_pin.sym} 6880 3410 0 0 {name=l1860 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 3380 0 0 {name=Xc_14_17
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 3350 0 0 {name=l1861 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 3410 0 0 {name=l1862 sig_type=std_logic lab=WL_14_II}
C {devices/lab_pin.sym} 7280 3350 0 0 {name=l1863 sig_type=std_logic lab=PL_14_II}
C {devices/lab_pin.sym} 7280 3410 0 0 {name=l1864 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 3380 0 0 {name=Xc_14_18
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 3350 0 0 {name=l1865 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 3410 0 0 {name=l1866 sig_type=std_logic lab=WL_14_II}
C {devices/lab_pin.sym} 7680 3350 0 0 {name=l1867 sig_type=std_logic lab=PL_14_II}
C {devices/lab_pin.sym} 7680 3410 0 0 {name=l1868 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 3380 0 0 {name=Xc_14_19
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 3350 0 0 {name=l1869 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 3410 0 0 {name=l1870 sig_type=std_logic lab=WL_14_II}
C {devices/lab_pin.sym} 8080 3350 0 0 {name=l1871 sig_type=std_logic lab=PL_14_II}
C {devices/lab_pin.sym} 8080 3410 0 0 {name=l1872 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 3380 0 0 {name=Xc_14_20
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 3350 0 0 {name=l1873 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 3410 0 0 {name=l1874 sig_type=std_logic lab=WL_14_II}
C {devices/lab_pin.sym} 8480 3350 0 0 {name=l1875 sig_type=std_logic lab=PL_14_II}
C {devices/lab_pin.sym} 8480 3410 0 0 {name=l1876 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 3380 0 0 {name=Xc_14_21
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 3350 0 0 {name=l1877 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 3410 0 0 {name=l1878 sig_type=std_logic lab=WL_14_II}
C {devices/lab_pin.sym} 8880 3350 0 0 {name=l1879 sig_type=std_logic lab=PL_14_II}
C {devices/lab_pin.sym} 8880 3410 0 0 {name=l1880 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 3380 0 0 {name=Xc_14_22
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 3350 0 0 {name=l1881 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 3410 0 0 {name=l1882 sig_type=std_logic lab=WL_14_III}
C {devices/lab_pin.sym} 9280 3350 0 0 {name=l1883 sig_type=std_logic lab=PL_14_III}
C {devices/lab_pin.sym} 9280 3410 0 0 {name=l1884 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 3380 0 0 {name=Xc_14_23
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 3350 0 0 {name=l1885 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 3410 0 0 {name=l1886 sig_type=std_logic lab=WL_14_III}
C {devices/lab_pin.sym} 9680 3350 0 0 {name=l1887 sig_type=std_logic lab=PL_14_III}
C {devices/lab_pin.sym} 9680 3410 0 0 {name=l1888 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 3380 0 0 {name=Xc_14_24
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 3350 0 0 {name=l1889 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 3410 0 0 {name=l1890 sig_type=std_logic lab=WL_14_III}
C {devices/lab_pin.sym} 10080 3350 0 0 {name=l1891 sig_type=std_logic lab=PL_14_III}
C {devices/lab_pin.sym} 10080 3410 0 0 {name=l1892 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 3380 0 0 {name=Xc_14_25
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 3350 0 0 {name=l1893 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 3410 0 0 {name=l1894 sig_type=std_logic lab=WL_14_III}
C {devices/lab_pin.sym} 10480 3350 0 0 {name=l1895 sig_type=std_logic lab=PL_14_III}
C {devices/lab_pin.sym} 10480 3410 0 0 {name=l1896 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 3380 0 0 {name=Xc_14_26
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 3350 0 0 {name=l1897 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 3410 0 0 {name=l1898 sig_type=std_logic lab=WL_14_III}
C {devices/lab_pin.sym} 10880 3350 0 0 {name=l1899 sig_type=std_logic lab=PL_14_III}
C {devices/lab_pin.sym} 10880 3410 0 0 {name=l1900 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 3380 0 0 {name=Xc_14_27
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 3350 0 0 {name=l1901 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 3410 0 0 {name=l1902 sig_type=std_logic lab=WL_14_III}
C {devices/lab_pin.sym} 11280 3350 0 0 {name=l1903 sig_type=std_logic lab=PL_14_III}
C {devices/lab_pin.sym} 11280 3410 0 0 {name=l1904 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 3380 0 0 {name=Xc_14_28
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 3350 0 0 {name=l1905 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 3410 0 0 {name=l1906 sig_type=std_logic lab=WL_14_III}
C {devices/lab_pin.sym} 11680 3350 0 0 {name=l1907 sig_type=std_logic lab=PL_14_III}
C {devices/lab_pin.sym} 11680 3410 0 0 {name=l1908 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 3380 0 0 {name=Xc_14_29
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 3350 0 0 {name=l1909 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 3410 0 0 {name=l1910 sig_type=std_logic lab=WL_14_III}
C {devices/lab_pin.sym} 12080 3350 0 0 {name=l1911 sig_type=std_logic lab=PL_14_III}
C {devices/lab_pin.sym} 12080 3410 0 0 {name=l1912 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 3380 0 0 {name=Xc_14_30
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 3350 0 0 {name=l1913 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 3410 0 0 {name=l1914 sig_type=std_logic lab=WL_14_III}
C {devices/lab_pin.sym} 12480 3350 0 0 {name=l1915 sig_type=std_logic lab=PL_14_III}
C {devices/lab_pin.sym} 12480 3410 0 0 {name=l1916 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 3380 0 0 {name=Xc_14_31
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 3350 0 0 {name=l1917 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 3410 0 0 {name=l1918 sig_type=std_logic lab=WL_14_III}
C {devices/lab_pin.sym} 12880 3350 0 0 {name=l1919 sig_type=std_logic lab=PL_14_III}
C {devices/lab_pin.sym} 12880 3410 0 0 {name=l1920 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 3600 0 0 {name=Xc_15_0
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 3570 0 0 {name=l1921 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 3630 0 0 {name=l1922 sig_type=std_logic lab=WL_15_I}
C {devices/lab_pin.sym} 480 3570 0 0 {name=l1923 sig_type=std_logic lab=PL_15_I}
C {devices/lab_pin.sym} 480 3630 0 0 {name=l1924 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 3600 0 0 {name=Xc_15_1
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 3570 0 0 {name=l1925 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 3630 0 0 {name=l1926 sig_type=std_logic lab=WL_15_I}
C {devices/lab_pin.sym} 880 3570 0 0 {name=l1927 sig_type=std_logic lab=PL_15_I}
C {devices/lab_pin.sym} 880 3630 0 0 {name=l1928 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 3600 0 0 {name=Xc_15_2
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 3570 0 0 {name=l1929 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 3630 0 0 {name=l1930 sig_type=std_logic lab=WL_15_I}
C {devices/lab_pin.sym} 1280 3570 0 0 {name=l1931 sig_type=std_logic lab=PL_15_I}
C {devices/lab_pin.sym} 1280 3630 0 0 {name=l1932 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 3600 0 0 {name=Xc_15_3
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 3570 0 0 {name=l1933 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 3630 0 0 {name=l1934 sig_type=std_logic lab=WL_15_I}
C {devices/lab_pin.sym} 1680 3570 0 0 {name=l1935 sig_type=std_logic lab=PL_15_I}
C {devices/lab_pin.sym} 1680 3630 0 0 {name=l1936 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 3600 0 0 {name=Xc_15_4
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 3570 0 0 {name=l1937 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 3630 0 0 {name=l1938 sig_type=std_logic lab=WL_15_I}
C {devices/lab_pin.sym} 2080 3570 0 0 {name=l1939 sig_type=std_logic lab=PL_15_I}
C {devices/lab_pin.sym} 2080 3630 0 0 {name=l1940 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 3600 0 0 {name=Xc_15_5
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 3570 0 0 {name=l1941 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 3630 0 0 {name=l1942 sig_type=std_logic lab=WL_15_I}
C {devices/lab_pin.sym} 2480 3570 0 0 {name=l1943 sig_type=std_logic lab=PL_15_I}
C {devices/lab_pin.sym} 2480 3630 0 0 {name=l1944 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 3600 0 0 {name=Xc_15_6
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 3570 0 0 {name=l1945 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 3630 0 0 {name=l1946 sig_type=std_logic lab=WL_15_I}
C {devices/lab_pin.sym} 2880 3570 0 0 {name=l1947 sig_type=std_logic lab=PL_15_I}
C {devices/lab_pin.sym} 2880 3630 0 0 {name=l1948 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 3600 0 0 {name=Xc_15_7
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 3570 0 0 {name=l1949 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 3630 0 0 {name=l1950 sig_type=std_logic lab=WL_15_I}
C {devices/lab_pin.sym} 3280 3570 0 0 {name=l1951 sig_type=std_logic lab=PL_15_I}
C {devices/lab_pin.sym} 3280 3630 0 0 {name=l1952 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 3600 0 0 {name=Xc_15_8
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 3570 0 0 {name=l1953 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 3630 0 0 {name=l1954 sig_type=std_logic lab=WL_15_I}
C {devices/lab_pin.sym} 3680 3570 0 0 {name=l1955 sig_type=std_logic lab=PL_15_I}
C {devices/lab_pin.sym} 3680 3630 0 0 {name=l1956 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 3600 0 0 {name=Xc_15_9
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 3570 0 0 {name=l1957 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 3630 0 0 {name=l1958 sig_type=std_logic lab=WL_15_I}
C {devices/lab_pin.sym} 4080 3570 0 0 {name=l1959 sig_type=std_logic lab=PL_15_I}
C {devices/lab_pin.sym} 4080 3630 0 0 {name=l1960 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 3600 0 0 {name=Xc_15_10
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 3570 0 0 {name=l1961 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 3630 0 0 {name=l1962 sig_type=std_logic lab=WL_15_I}
C {devices/lab_pin.sym} 4480 3570 0 0 {name=l1963 sig_type=std_logic lab=PL_15_I}
C {devices/lab_pin.sym} 4480 3630 0 0 {name=l1964 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 3600 0 0 {name=Xc_15_11
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 3570 0 0 {name=l1965 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 3630 0 0 {name=l1966 sig_type=std_logic lab=WL_15_II}
C {devices/lab_pin.sym} 4880 3570 0 0 {name=l1967 sig_type=std_logic lab=PL_15_II}
C {devices/lab_pin.sym} 4880 3630 0 0 {name=l1968 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 3600 0 0 {name=Xc_15_12
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 3570 0 0 {name=l1969 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 3630 0 0 {name=l1970 sig_type=std_logic lab=WL_15_II}
C {devices/lab_pin.sym} 5280 3570 0 0 {name=l1971 sig_type=std_logic lab=PL_15_II}
C {devices/lab_pin.sym} 5280 3630 0 0 {name=l1972 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 3600 0 0 {name=Xc_15_13
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 3570 0 0 {name=l1973 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 3630 0 0 {name=l1974 sig_type=std_logic lab=WL_15_II}
C {devices/lab_pin.sym} 5680 3570 0 0 {name=l1975 sig_type=std_logic lab=PL_15_II}
C {devices/lab_pin.sym} 5680 3630 0 0 {name=l1976 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 3600 0 0 {name=Xc_15_14
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 3570 0 0 {name=l1977 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 3630 0 0 {name=l1978 sig_type=std_logic lab=WL_15_II}
C {devices/lab_pin.sym} 6080 3570 0 0 {name=l1979 sig_type=std_logic lab=PL_15_II}
C {devices/lab_pin.sym} 6080 3630 0 0 {name=l1980 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 3600 0 0 {name=Xc_15_15
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 3570 0 0 {name=l1981 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 3630 0 0 {name=l1982 sig_type=std_logic lab=WL_15_II}
C {devices/lab_pin.sym} 6480 3570 0 0 {name=l1983 sig_type=std_logic lab=PL_15_II}
C {devices/lab_pin.sym} 6480 3630 0 0 {name=l1984 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 3600 0 0 {name=Xc_15_16
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 3570 0 0 {name=l1985 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 3630 0 0 {name=l1986 sig_type=std_logic lab=WL_15_II}
C {devices/lab_pin.sym} 6880 3570 0 0 {name=l1987 sig_type=std_logic lab=PL_15_II}
C {devices/lab_pin.sym} 6880 3630 0 0 {name=l1988 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 3600 0 0 {name=Xc_15_17
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 3570 0 0 {name=l1989 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 3630 0 0 {name=l1990 sig_type=std_logic lab=WL_15_II}
C {devices/lab_pin.sym} 7280 3570 0 0 {name=l1991 sig_type=std_logic lab=PL_15_II}
C {devices/lab_pin.sym} 7280 3630 0 0 {name=l1992 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 3600 0 0 {name=Xc_15_18
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 3570 0 0 {name=l1993 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 3630 0 0 {name=l1994 sig_type=std_logic lab=WL_15_II}
C {devices/lab_pin.sym} 7680 3570 0 0 {name=l1995 sig_type=std_logic lab=PL_15_II}
C {devices/lab_pin.sym} 7680 3630 0 0 {name=l1996 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 3600 0 0 {name=Xc_15_19
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 3570 0 0 {name=l1997 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 3630 0 0 {name=l1998 sig_type=std_logic lab=WL_15_II}
C {devices/lab_pin.sym} 8080 3570 0 0 {name=l1999 sig_type=std_logic lab=PL_15_II}
C {devices/lab_pin.sym} 8080 3630 0 0 {name=l2000 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 3600 0 0 {name=Xc_15_20
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 3570 0 0 {name=l2001 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 3630 0 0 {name=l2002 sig_type=std_logic lab=WL_15_II}
C {devices/lab_pin.sym} 8480 3570 0 0 {name=l2003 sig_type=std_logic lab=PL_15_II}
C {devices/lab_pin.sym} 8480 3630 0 0 {name=l2004 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 3600 0 0 {name=Xc_15_21
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 3570 0 0 {name=l2005 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 3630 0 0 {name=l2006 sig_type=std_logic lab=WL_15_II}
C {devices/lab_pin.sym} 8880 3570 0 0 {name=l2007 sig_type=std_logic lab=PL_15_II}
C {devices/lab_pin.sym} 8880 3630 0 0 {name=l2008 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 3600 0 0 {name=Xc_15_22
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 3570 0 0 {name=l2009 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 3630 0 0 {name=l2010 sig_type=std_logic lab=WL_15_III}
C {devices/lab_pin.sym} 9280 3570 0 0 {name=l2011 sig_type=std_logic lab=PL_15_III}
C {devices/lab_pin.sym} 9280 3630 0 0 {name=l2012 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 3600 0 0 {name=Xc_15_23
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 3570 0 0 {name=l2013 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 3630 0 0 {name=l2014 sig_type=std_logic lab=WL_15_III}
C {devices/lab_pin.sym} 9680 3570 0 0 {name=l2015 sig_type=std_logic lab=PL_15_III}
C {devices/lab_pin.sym} 9680 3630 0 0 {name=l2016 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 3600 0 0 {name=Xc_15_24
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 3570 0 0 {name=l2017 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 3630 0 0 {name=l2018 sig_type=std_logic lab=WL_15_III}
C {devices/lab_pin.sym} 10080 3570 0 0 {name=l2019 sig_type=std_logic lab=PL_15_III}
C {devices/lab_pin.sym} 10080 3630 0 0 {name=l2020 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 3600 0 0 {name=Xc_15_25
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 3570 0 0 {name=l2021 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 3630 0 0 {name=l2022 sig_type=std_logic lab=WL_15_III}
C {devices/lab_pin.sym} 10480 3570 0 0 {name=l2023 sig_type=std_logic lab=PL_15_III}
C {devices/lab_pin.sym} 10480 3630 0 0 {name=l2024 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 3600 0 0 {name=Xc_15_26
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 3570 0 0 {name=l2025 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 3630 0 0 {name=l2026 sig_type=std_logic lab=WL_15_III}
C {devices/lab_pin.sym} 10880 3570 0 0 {name=l2027 sig_type=std_logic lab=PL_15_III}
C {devices/lab_pin.sym} 10880 3630 0 0 {name=l2028 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 3600 0 0 {name=Xc_15_27
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 3570 0 0 {name=l2029 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 3630 0 0 {name=l2030 sig_type=std_logic lab=WL_15_III}
C {devices/lab_pin.sym} 11280 3570 0 0 {name=l2031 sig_type=std_logic lab=PL_15_III}
C {devices/lab_pin.sym} 11280 3630 0 0 {name=l2032 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 3600 0 0 {name=Xc_15_28
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 3570 0 0 {name=l2033 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 3630 0 0 {name=l2034 sig_type=std_logic lab=WL_15_III}
C {devices/lab_pin.sym} 11680 3570 0 0 {name=l2035 sig_type=std_logic lab=PL_15_III}
C {devices/lab_pin.sym} 11680 3630 0 0 {name=l2036 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 3600 0 0 {name=Xc_15_29
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 3570 0 0 {name=l2037 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 3630 0 0 {name=l2038 sig_type=std_logic lab=WL_15_III}
C {devices/lab_pin.sym} 12080 3570 0 0 {name=l2039 sig_type=std_logic lab=PL_15_III}
C {devices/lab_pin.sym} 12080 3630 0 0 {name=l2040 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 3600 0 0 {name=Xc_15_30
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 3570 0 0 {name=l2041 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 3630 0 0 {name=l2042 sig_type=std_logic lab=WL_15_III}
C {devices/lab_pin.sym} 12480 3570 0 0 {name=l2043 sig_type=std_logic lab=PL_15_III}
C {devices/lab_pin.sym} 12480 3630 0 0 {name=l2044 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 3600 0 0 {name=Xc_15_31
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 3570 0 0 {name=l2045 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 3630 0 0 {name=l2046 sig_type=std_logic lab=WL_15_III}
C {devices/lab_pin.sym} 12880 3570 0 0 {name=l2047 sig_type=std_logic lab=PL_15_III}
C {devices/lab_pin.sym} 12880 3630 0 0 {name=l2048 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 3820 0 0 {name=Xc_16_0
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 3790 0 0 {name=l2049 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 3850 0 0 {name=l2050 sig_type=std_logic lab=WL_16_I}
C {devices/lab_pin.sym} 480 3790 0 0 {name=l2051 sig_type=std_logic lab=PL_16_I}
C {devices/lab_pin.sym} 480 3850 0 0 {name=l2052 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 3820 0 0 {name=Xc_16_1
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 3790 0 0 {name=l2053 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 3850 0 0 {name=l2054 sig_type=std_logic lab=WL_16_I}
C {devices/lab_pin.sym} 880 3790 0 0 {name=l2055 sig_type=std_logic lab=PL_16_I}
C {devices/lab_pin.sym} 880 3850 0 0 {name=l2056 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 3820 0 0 {name=Xc_16_2
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 3790 0 0 {name=l2057 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 3850 0 0 {name=l2058 sig_type=std_logic lab=WL_16_I}
C {devices/lab_pin.sym} 1280 3790 0 0 {name=l2059 sig_type=std_logic lab=PL_16_I}
C {devices/lab_pin.sym} 1280 3850 0 0 {name=l2060 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 3820 0 0 {name=Xc_16_3
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 3790 0 0 {name=l2061 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 3850 0 0 {name=l2062 sig_type=std_logic lab=WL_16_I}
C {devices/lab_pin.sym} 1680 3790 0 0 {name=l2063 sig_type=std_logic lab=PL_16_I}
C {devices/lab_pin.sym} 1680 3850 0 0 {name=l2064 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 3820 0 0 {name=Xc_16_4
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 3790 0 0 {name=l2065 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 3850 0 0 {name=l2066 sig_type=std_logic lab=WL_16_I}
C {devices/lab_pin.sym} 2080 3790 0 0 {name=l2067 sig_type=std_logic lab=PL_16_I}
C {devices/lab_pin.sym} 2080 3850 0 0 {name=l2068 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 3820 0 0 {name=Xc_16_5
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 3790 0 0 {name=l2069 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 3850 0 0 {name=l2070 sig_type=std_logic lab=WL_16_I}
C {devices/lab_pin.sym} 2480 3790 0 0 {name=l2071 sig_type=std_logic lab=PL_16_I}
C {devices/lab_pin.sym} 2480 3850 0 0 {name=l2072 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 3820 0 0 {name=Xc_16_6
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 3790 0 0 {name=l2073 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 3850 0 0 {name=l2074 sig_type=std_logic lab=WL_16_I}
C {devices/lab_pin.sym} 2880 3790 0 0 {name=l2075 sig_type=std_logic lab=PL_16_I}
C {devices/lab_pin.sym} 2880 3850 0 0 {name=l2076 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 3820 0 0 {name=Xc_16_7
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 3790 0 0 {name=l2077 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 3850 0 0 {name=l2078 sig_type=std_logic lab=WL_16_I}
C {devices/lab_pin.sym} 3280 3790 0 0 {name=l2079 sig_type=std_logic lab=PL_16_I}
C {devices/lab_pin.sym} 3280 3850 0 0 {name=l2080 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 3820 0 0 {name=Xc_16_8
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 3790 0 0 {name=l2081 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 3850 0 0 {name=l2082 sig_type=std_logic lab=WL_16_I}
C {devices/lab_pin.sym} 3680 3790 0 0 {name=l2083 sig_type=std_logic lab=PL_16_I}
C {devices/lab_pin.sym} 3680 3850 0 0 {name=l2084 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 3820 0 0 {name=Xc_16_9
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 3790 0 0 {name=l2085 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 3850 0 0 {name=l2086 sig_type=std_logic lab=WL_16_I}
C {devices/lab_pin.sym} 4080 3790 0 0 {name=l2087 sig_type=std_logic lab=PL_16_I}
C {devices/lab_pin.sym} 4080 3850 0 0 {name=l2088 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 3820 0 0 {name=Xc_16_10
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 3790 0 0 {name=l2089 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 3850 0 0 {name=l2090 sig_type=std_logic lab=WL_16_I}
C {devices/lab_pin.sym} 4480 3790 0 0 {name=l2091 sig_type=std_logic lab=PL_16_I}
C {devices/lab_pin.sym} 4480 3850 0 0 {name=l2092 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 3820 0 0 {name=Xc_16_11
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 3790 0 0 {name=l2093 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 3850 0 0 {name=l2094 sig_type=std_logic lab=WL_16_II}
C {devices/lab_pin.sym} 4880 3790 0 0 {name=l2095 sig_type=std_logic lab=PL_16_II}
C {devices/lab_pin.sym} 4880 3850 0 0 {name=l2096 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 3820 0 0 {name=Xc_16_12
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 3790 0 0 {name=l2097 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 3850 0 0 {name=l2098 sig_type=std_logic lab=WL_16_II}
C {devices/lab_pin.sym} 5280 3790 0 0 {name=l2099 sig_type=std_logic lab=PL_16_II}
C {devices/lab_pin.sym} 5280 3850 0 0 {name=l2100 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 3820 0 0 {name=Xc_16_13
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 3790 0 0 {name=l2101 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 3850 0 0 {name=l2102 sig_type=std_logic lab=WL_16_II}
C {devices/lab_pin.sym} 5680 3790 0 0 {name=l2103 sig_type=std_logic lab=PL_16_II}
C {devices/lab_pin.sym} 5680 3850 0 0 {name=l2104 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 3820 0 0 {name=Xc_16_14
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 3790 0 0 {name=l2105 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 3850 0 0 {name=l2106 sig_type=std_logic lab=WL_16_II}
C {devices/lab_pin.sym} 6080 3790 0 0 {name=l2107 sig_type=std_logic lab=PL_16_II}
C {devices/lab_pin.sym} 6080 3850 0 0 {name=l2108 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 3820 0 0 {name=Xc_16_15
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 3790 0 0 {name=l2109 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 3850 0 0 {name=l2110 sig_type=std_logic lab=WL_16_II}
C {devices/lab_pin.sym} 6480 3790 0 0 {name=l2111 sig_type=std_logic lab=PL_16_II}
C {devices/lab_pin.sym} 6480 3850 0 0 {name=l2112 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 3820 0 0 {name=Xc_16_16
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 3790 0 0 {name=l2113 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 3850 0 0 {name=l2114 sig_type=std_logic lab=WL_16_II}
C {devices/lab_pin.sym} 6880 3790 0 0 {name=l2115 sig_type=std_logic lab=PL_16_II}
C {devices/lab_pin.sym} 6880 3850 0 0 {name=l2116 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 3820 0 0 {name=Xc_16_17
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 3790 0 0 {name=l2117 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 3850 0 0 {name=l2118 sig_type=std_logic lab=WL_16_II}
C {devices/lab_pin.sym} 7280 3790 0 0 {name=l2119 sig_type=std_logic lab=PL_16_II}
C {devices/lab_pin.sym} 7280 3850 0 0 {name=l2120 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 3820 0 0 {name=Xc_16_18
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 3790 0 0 {name=l2121 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 3850 0 0 {name=l2122 sig_type=std_logic lab=WL_16_II}
C {devices/lab_pin.sym} 7680 3790 0 0 {name=l2123 sig_type=std_logic lab=PL_16_II}
C {devices/lab_pin.sym} 7680 3850 0 0 {name=l2124 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 3820 0 0 {name=Xc_16_19
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 3790 0 0 {name=l2125 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 3850 0 0 {name=l2126 sig_type=std_logic lab=WL_16_II}
C {devices/lab_pin.sym} 8080 3790 0 0 {name=l2127 sig_type=std_logic lab=PL_16_II}
C {devices/lab_pin.sym} 8080 3850 0 0 {name=l2128 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 3820 0 0 {name=Xc_16_20
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 3790 0 0 {name=l2129 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 3850 0 0 {name=l2130 sig_type=std_logic lab=WL_16_II}
C {devices/lab_pin.sym} 8480 3790 0 0 {name=l2131 sig_type=std_logic lab=PL_16_II}
C {devices/lab_pin.sym} 8480 3850 0 0 {name=l2132 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 3820 0 0 {name=Xc_16_21
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 3790 0 0 {name=l2133 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 3850 0 0 {name=l2134 sig_type=std_logic lab=WL_16_II}
C {devices/lab_pin.sym} 8880 3790 0 0 {name=l2135 sig_type=std_logic lab=PL_16_II}
C {devices/lab_pin.sym} 8880 3850 0 0 {name=l2136 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 3820 0 0 {name=Xc_16_22
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 3790 0 0 {name=l2137 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 3850 0 0 {name=l2138 sig_type=std_logic lab=WL_16_III}
C {devices/lab_pin.sym} 9280 3790 0 0 {name=l2139 sig_type=std_logic lab=PL_16_III}
C {devices/lab_pin.sym} 9280 3850 0 0 {name=l2140 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 3820 0 0 {name=Xc_16_23
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 3790 0 0 {name=l2141 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 3850 0 0 {name=l2142 sig_type=std_logic lab=WL_16_III}
C {devices/lab_pin.sym} 9680 3790 0 0 {name=l2143 sig_type=std_logic lab=PL_16_III}
C {devices/lab_pin.sym} 9680 3850 0 0 {name=l2144 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 3820 0 0 {name=Xc_16_24
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 3790 0 0 {name=l2145 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 3850 0 0 {name=l2146 sig_type=std_logic lab=WL_16_III}
C {devices/lab_pin.sym} 10080 3790 0 0 {name=l2147 sig_type=std_logic lab=PL_16_III}
C {devices/lab_pin.sym} 10080 3850 0 0 {name=l2148 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 3820 0 0 {name=Xc_16_25
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 3790 0 0 {name=l2149 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 3850 0 0 {name=l2150 sig_type=std_logic lab=WL_16_III}
C {devices/lab_pin.sym} 10480 3790 0 0 {name=l2151 sig_type=std_logic lab=PL_16_III}
C {devices/lab_pin.sym} 10480 3850 0 0 {name=l2152 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 3820 0 0 {name=Xc_16_26
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 3790 0 0 {name=l2153 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 3850 0 0 {name=l2154 sig_type=std_logic lab=WL_16_III}
C {devices/lab_pin.sym} 10880 3790 0 0 {name=l2155 sig_type=std_logic lab=PL_16_III}
C {devices/lab_pin.sym} 10880 3850 0 0 {name=l2156 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 3820 0 0 {name=Xc_16_27
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 3790 0 0 {name=l2157 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 3850 0 0 {name=l2158 sig_type=std_logic lab=WL_16_III}
C {devices/lab_pin.sym} 11280 3790 0 0 {name=l2159 sig_type=std_logic lab=PL_16_III}
C {devices/lab_pin.sym} 11280 3850 0 0 {name=l2160 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 3820 0 0 {name=Xc_16_28
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 3790 0 0 {name=l2161 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 3850 0 0 {name=l2162 sig_type=std_logic lab=WL_16_III}
C {devices/lab_pin.sym} 11680 3790 0 0 {name=l2163 sig_type=std_logic lab=PL_16_III}
C {devices/lab_pin.sym} 11680 3850 0 0 {name=l2164 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 3820 0 0 {name=Xc_16_29
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 3790 0 0 {name=l2165 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 3850 0 0 {name=l2166 sig_type=std_logic lab=WL_16_III}
C {devices/lab_pin.sym} 12080 3790 0 0 {name=l2167 sig_type=std_logic lab=PL_16_III}
C {devices/lab_pin.sym} 12080 3850 0 0 {name=l2168 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 3820 0 0 {name=Xc_16_30
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 3790 0 0 {name=l2169 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 3850 0 0 {name=l2170 sig_type=std_logic lab=WL_16_III}
C {devices/lab_pin.sym} 12480 3790 0 0 {name=l2171 sig_type=std_logic lab=PL_16_III}
C {devices/lab_pin.sym} 12480 3850 0 0 {name=l2172 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 3820 0 0 {name=Xc_16_31
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 3790 0 0 {name=l2173 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 3850 0 0 {name=l2174 sig_type=std_logic lab=WL_16_III}
C {devices/lab_pin.sym} 12880 3790 0 0 {name=l2175 sig_type=std_logic lab=PL_16_III}
C {devices/lab_pin.sym} 12880 3850 0 0 {name=l2176 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 4040 0 0 {name=Xc_17_0
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 4010 0 0 {name=l2177 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 4070 0 0 {name=l2178 sig_type=std_logic lab=WL_17_I}
C {devices/lab_pin.sym} 480 4010 0 0 {name=l2179 sig_type=std_logic lab=PL_17_I}
C {devices/lab_pin.sym} 480 4070 0 0 {name=l2180 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 4040 0 0 {name=Xc_17_1
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 4010 0 0 {name=l2181 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 4070 0 0 {name=l2182 sig_type=std_logic lab=WL_17_I}
C {devices/lab_pin.sym} 880 4010 0 0 {name=l2183 sig_type=std_logic lab=PL_17_I}
C {devices/lab_pin.sym} 880 4070 0 0 {name=l2184 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 4040 0 0 {name=Xc_17_2
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 4010 0 0 {name=l2185 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 4070 0 0 {name=l2186 sig_type=std_logic lab=WL_17_I}
C {devices/lab_pin.sym} 1280 4010 0 0 {name=l2187 sig_type=std_logic lab=PL_17_I}
C {devices/lab_pin.sym} 1280 4070 0 0 {name=l2188 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 4040 0 0 {name=Xc_17_3
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 4010 0 0 {name=l2189 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 4070 0 0 {name=l2190 sig_type=std_logic lab=WL_17_I}
C {devices/lab_pin.sym} 1680 4010 0 0 {name=l2191 sig_type=std_logic lab=PL_17_I}
C {devices/lab_pin.sym} 1680 4070 0 0 {name=l2192 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 4040 0 0 {name=Xc_17_4
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 4010 0 0 {name=l2193 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 4070 0 0 {name=l2194 sig_type=std_logic lab=WL_17_I}
C {devices/lab_pin.sym} 2080 4010 0 0 {name=l2195 sig_type=std_logic lab=PL_17_I}
C {devices/lab_pin.sym} 2080 4070 0 0 {name=l2196 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 4040 0 0 {name=Xc_17_5
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 4010 0 0 {name=l2197 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 4070 0 0 {name=l2198 sig_type=std_logic lab=WL_17_I}
C {devices/lab_pin.sym} 2480 4010 0 0 {name=l2199 sig_type=std_logic lab=PL_17_I}
C {devices/lab_pin.sym} 2480 4070 0 0 {name=l2200 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 4040 0 0 {name=Xc_17_6
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 4010 0 0 {name=l2201 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 4070 0 0 {name=l2202 sig_type=std_logic lab=WL_17_I}
C {devices/lab_pin.sym} 2880 4010 0 0 {name=l2203 sig_type=std_logic lab=PL_17_I}
C {devices/lab_pin.sym} 2880 4070 0 0 {name=l2204 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 4040 0 0 {name=Xc_17_7
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 4010 0 0 {name=l2205 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 4070 0 0 {name=l2206 sig_type=std_logic lab=WL_17_I}
C {devices/lab_pin.sym} 3280 4010 0 0 {name=l2207 sig_type=std_logic lab=PL_17_I}
C {devices/lab_pin.sym} 3280 4070 0 0 {name=l2208 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 4040 0 0 {name=Xc_17_8
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 4010 0 0 {name=l2209 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 4070 0 0 {name=l2210 sig_type=std_logic lab=WL_17_I}
C {devices/lab_pin.sym} 3680 4010 0 0 {name=l2211 sig_type=std_logic lab=PL_17_I}
C {devices/lab_pin.sym} 3680 4070 0 0 {name=l2212 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 4040 0 0 {name=Xc_17_9
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 4010 0 0 {name=l2213 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 4070 0 0 {name=l2214 sig_type=std_logic lab=WL_17_I}
C {devices/lab_pin.sym} 4080 4010 0 0 {name=l2215 sig_type=std_logic lab=PL_17_I}
C {devices/lab_pin.sym} 4080 4070 0 0 {name=l2216 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 4040 0 0 {name=Xc_17_10
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 4010 0 0 {name=l2217 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 4070 0 0 {name=l2218 sig_type=std_logic lab=WL_17_I}
C {devices/lab_pin.sym} 4480 4010 0 0 {name=l2219 sig_type=std_logic lab=PL_17_I}
C {devices/lab_pin.sym} 4480 4070 0 0 {name=l2220 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 4040 0 0 {name=Xc_17_11
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 4010 0 0 {name=l2221 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 4070 0 0 {name=l2222 sig_type=std_logic lab=WL_17_II}
C {devices/lab_pin.sym} 4880 4010 0 0 {name=l2223 sig_type=std_logic lab=PL_17_II}
C {devices/lab_pin.sym} 4880 4070 0 0 {name=l2224 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 4040 0 0 {name=Xc_17_12
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 4010 0 0 {name=l2225 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 4070 0 0 {name=l2226 sig_type=std_logic lab=WL_17_II}
C {devices/lab_pin.sym} 5280 4010 0 0 {name=l2227 sig_type=std_logic lab=PL_17_II}
C {devices/lab_pin.sym} 5280 4070 0 0 {name=l2228 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 4040 0 0 {name=Xc_17_13
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 4010 0 0 {name=l2229 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 4070 0 0 {name=l2230 sig_type=std_logic lab=WL_17_II}
C {devices/lab_pin.sym} 5680 4010 0 0 {name=l2231 sig_type=std_logic lab=PL_17_II}
C {devices/lab_pin.sym} 5680 4070 0 0 {name=l2232 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 4040 0 0 {name=Xc_17_14
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 4010 0 0 {name=l2233 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 4070 0 0 {name=l2234 sig_type=std_logic lab=WL_17_II}
C {devices/lab_pin.sym} 6080 4010 0 0 {name=l2235 sig_type=std_logic lab=PL_17_II}
C {devices/lab_pin.sym} 6080 4070 0 0 {name=l2236 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 4040 0 0 {name=Xc_17_15
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 4010 0 0 {name=l2237 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 4070 0 0 {name=l2238 sig_type=std_logic lab=WL_17_II}
C {devices/lab_pin.sym} 6480 4010 0 0 {name=l2239 sig_type=std_logic lab=PL_17_II}
C {devices/lab_pin.sym} 6480 4070 0 0 {name=l2240 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 4040 0 0 {name=Xc_17_16
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 4010 0 0 {name=l2241 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 4070 0 0 {name=l2242 sig_type=std_logic lab=WL_17_II}
C {devices/lab_pin.sym} 6880 4010 0 0 {name=l2243 sig_type=std_logic lab=PL_17_II}
C {devices/lab_pin.sym} 6880 4070 0 0 {name=l2244 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 4040 0 0 {name=Xc_17_17
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 4010 0 0 {name=l2245 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 4070 0 0 {name=l2246 sig_type=std_logic lab=WL_17_II}
C {devices/lab_pin.sym} 7280 4010 0 0 {name=l2247 sig_type=std_logic lab=PL_17_II}
C {devices/lab_pin.sym} 7280 4070 0 0 {name=l2248 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 4040 0 0 {name=Xc_17_18
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 4010 0 0 {name=l2249 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 4070 0 0 {name=l2250 sig_type=std_logic lab=WL_17_II}
C {devices/lab_pin.sym} 7680 4010 0 0 {name=l2251 sig_type=std_logic lab=PL_17_II}
C {devices/lab_pin.sym} 7680 4070 0 0 {name=l2252 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 4040 0 0 {name=Xc_17_19
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 4010 0 0 {name=l2253 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 4070 0 0 {name=l2254 sig_type=std_logic lab=WL_17_II}
C {devices/lab_pin.sym} 8080 4010 0 0 {name=l2255 sig_type=std_logic lab=PL_17_II}
C {devices/lab_pin.sym} 8080 4070 0 0 {name=l2256 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 4040 0 0 {name=Xc_17_20
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 4010 0 0 {name=l2257 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 4070 0 0 {name=l2258 sig_type=std_logic lab=WL_17_II}
C {devices/lab_pin.sym} 8480 4010 0 0 {name=l2259 sig_type=std_logic lab=PL_17_II}
C {devices/lab_pin.sym} 8480 4070 0 0 {name=l2260 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 4040 0 0 {name=Xc_17_21
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 4010 0 0 {name=l2261 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 4070 0 0 {name=l2262 sig_type=std_logic lab=WL_17_II}
C {devices/lab_pin.sym} 8880 4010 0 0 {name=l2263 sig_type=std_logic lab=PL_17_II}
C {devices/lab_pin.sym} 8880 4070 0 0 {name=l2264 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 4040 0 0 {name=Xc_17_22
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 4010 0 0 {name=l2265 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 4070 0 0 {name=l2266 sig_type=std_logic lab=WL_17_III}
C {devices/lab_pin.sym} 9280 4010 0 0 {name=l2267 sig_type=std_logic lab=PL_17_III}
C {devices/lab_pin.sym} 9280 4070 0 0 {name=l2268 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 4040 0 0 {name=Xc_17_23
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 4010 0 0 {name=l2269 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 4070 0 0 {name=l2270 sig_type=std_logic lab=WL_17_III}
C {devices/lab_pin.sym} 9680 4010 0 0 {name=l2271 sig_type=std_logic lab=PL_17_III}
C {devices/lab_pin.sym} 9680 4070 0 0 {name=l2272 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 4040 0 0 {name=Xc_17_24
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 4010 0 0 {name=l2273 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 4070 0 0 {name=l2274 sig_type=std_logic lab=WL_17_III}
C {devices/lab_pin.sym} 10080 4010 0 0 {name=l2275 sig_type=std_logic lab=PL_17_III}
C {devices/lab_pin.sym} 10080 4070 0 0 {name=l2276 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 4040 0 0 {name=Xc_17_25
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 4010 0 0 {name=l2277 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 4070 0 0 {name=l2278 sig_type=std_logic lab=WL_17_III}
C {devices/lab_pin.sym} 10480 4010 0 0 {name=l2279 sig_type=std_logic lab=PL_17_III}
C {devices/lab_pin.sym} 10480 4070 0 0 {name=l2280 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 4040 0 0 {name=Xc_17_26
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 4010 0 0 {name=l2281 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 4070 0 0 {name=l2282 sig_type=std_logic lab=WL_17_III}
C {devices/lab_pin.sym} 10880 4010 0 0 {name=l2283 sig_type=std_logic lab=PL_17_III}
C {devices/lab_pin.sym} 10880 4070 0 0 {name=l2284 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 4040 0 0 {name=Xc_17_27
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 4010 0 0 {name=l2285 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 4070 0 0 {name=l2286 sig_type=std_logic lab=WL_17_III}
C {devices/lab_pin.sym} 11280 4010 0 0 {name=l2287 sig_type=std_logic lab=PL_17_III}
C {devices/lab_pin.sym} 11280 4070 0 0 {name=l2288 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 4040 0 0 {name=Xc_17_28
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 4010 0 0 {name=l2289 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 4070 0 0 {name=l2290 sig_type=std_logic lab=WL_17_III}
C {devices/lab_pin.sym} 11680 4010 0 0 {name=l2291 sig_type=std_logic lab=PL_17_III}
C {devices/lab_pin.sym} 11680 4070 0 0 {name=l2292 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 4040 0 0 {name=Xc_17_29
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 4010 0 0 {name=l2293 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 4070 0 0 {name=l2294 sig_type=std_logic lab=WL_17_III}
C {devices/lab_pin.sym} 12080 4010 0 0 {name=l2295 sig_type=std_logic lab=PL_17_III}
C {devices/lab_pin.sym} 12080 4070 0 0 {name=l2296 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 4040 0 0 {name=Xc_17_30
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 4010 0 0 {name=l2297 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 4070 0 0 {name=l2298 sig_type=std_logic lab=WL_17_III}
C {devices/lab_pin.sym} 12480 4010 0 0 {name=l2299 sig_type=std_logic lab=PL_17_III}
C {devices/lab_pin.sym} 12480 4070 0 0 {name=l2300 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 4040 0 0 {name=Xc_17_31
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 4010 0 0 {name=l2301 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 4070 0 0 {name=l2302 sig_type=std_logic lab=WL_17_III}
C {devices/lab_pin.sym} 12880 4010 0 0 {name=l2303 sig_type=std_logic lab=PL_17_III}
C {devices/lab_pin.sym} 12880 4070 0 0 {name=l2304 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 4260 0 0 {name=Xc_18_0
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 4230 0 0 {name=l2305 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 4290 0 0 {name=l2306 sig_type=std_logic lab=WL_18_I}
C {devices/lab_pin.sym} 480 4230 0 0 {name=l2307 sig_type=std_logic lab=PL_18_I}
C {devices/lab_pin.sym} 480 4290 0 0 {name=l2308 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 4260 0 0 {name=Xc_18_1
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 4230 0 0 {name=l2309 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 4290 0 0 {name=l2310 sig_type=std_logic lab=WL_18_I}
C {devices/lab_pin.sym} 880 4230 0 0 {name=l2311 sig_type=std_logic lab=PL_18_I}
C {devices/lab_pin.sym} 880 4290 0 0 {name=l2312 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 4260 0 0 {name=Xc_18_2
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 4230 0 0 {name=l2313 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 4290 0 0 {name=l2314 sig_type=std_logic lab=WL_18_I}
C {devices/lab_pin.sym} 1280 4230 0 0 {name=l2315 sig_type=std_logic lab=PL_18_I}
C {devices/lab_pin.sym} 1280 4290 0 0 {name=l2316 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 4260 0 0 {name=Xc_18_3
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 4230 0 0 {name=l2317 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 4290 0 0 {name=l2318 sig_type=std_logic lab=WL_18_I}
C {devices/lab_pin.sym} 1680 4230 0 0 {name=l2319 sig_type=std_logic lab=PL_18_I}
C {devices/lab_pin.sym} 1680 4290 0 0 {name=l2320 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 4260 0 0 {name=Xc_18_4
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 4230 0 0 {name=l2321 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 4290 0 0 {name=l2322 sig_type=std_logic lab=WL_18_I}
C {devices/lab_pin.sym} 2080 4230 0 0 {name=l2323 sig_type=std_logic lab=PL_18_I}
C {devices/lab_pin.sym} 2080 4290 0 0 {name=l2324 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 4260 0 0 {name=Xc_18_5
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 4230 0 0 {name=l2325 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 4290 0 0 {name=l2326 sig_type=std_logic lab=WL_18_I}
C {devices/lab_pin.sym} 2480 4230 0 0 {name=l2327 sig_type=std_logic lab=PL_18_I}
C {devices/lab_pin.sym} 2480 4290 0 0 {name=l2328 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 4260 0 0 {name=Xc_18_6
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 4230 0 0 {name=l2329 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 4290 0 0 {name=l2330 sig_type=std_logic lab=WL_18_I}
C {devices/lab_pin.sym} 2880 4230 0 0 {name=l2331 sig_type=std_logic lab=PL_18_I}
C {devices/lab_pin.sym} 2880 4290 0 0 {name=l2332 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 4260 0 0 {name=Xc_18_7
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 4230 0 0 {name=l2333 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 4290 0 0 {name=l2334 sig_type=std_logic lab=WL_18_I}
C {devices/lab_pin.sym} 3280 4230 0 0 {name=l2335 sig_type=std_logic lab=PL_18_I}
C {devices/lab_pin.sym} 3280 4290 0 0 {name=l2336 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 4260 0 0 {name=Xc_18_8
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 4230 0 0 {name=l2337 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 4290 0 0 {name=l2338 sig_type=std_logic lab=WL_18_I}
C {devices/lab_pin.sym} 3680 4230 0 0 {name=l2339 sig_type=std_logic lab=PL_18_I}
C {devices/lab_pin.sym} 3680 4290 0 0 {name=l2340 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 4260 0 0 {name=Xc_18_9
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 4230 0 0 {name=l2341 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 4290 0 0 {name=l2342 sig_type=std_logic lab=WL_18_I}
C {devices/lab_pin.sym} 4080 4230 0 0 {name=l2343 sig_type=std_logic lab=PL_18_I}
C {devices/lab_pin.sym} 4080 4290 0 0 {name=l2344 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 4260 0 0 {name=Xc_18_10
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 4230 0 0 {name=l2345 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 4290 0 0 {name=l2346 sig_type=std_logic lab=WL_18_I}
C {devices/lab_pin.sym} 4480 4230 0 0 {name=l2347 sig_type=std_logic lab=PL_18_I}
C {devices/lab_pin.sym} 4480 4290 0 0 {name=l2348 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 4260 0 0 {name=Xc_18_11
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 4230 0 0 {name=l2349 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 4290 0 0 {name=l2350 sig_type=std_logic lab=WL_18_II}
C {devices/lab_pin.sym} 4880 4230 0 0 {name=l2351 sig_type=std_logic lab=PL_18_II}
C {devices/lab_pin.sym} 4880 4290 0 0 {name=l2352 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 4260 0 0 {name=Xc_18_12
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 4230 0 0 {name=l2353 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 4290 0 0 {name=l2354 sig_type=std_logic lab=WL_18_II}
C {devices/lab_pin.sym} 5280 4230 0 0 {name=l2355 sig_type=std_logic lab=PL_18_II}
C {devices/lab_pin.sym} 5280 4290 0 0 {name=l2356 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 4260 0 0 {name=Xc_18_13
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 4230 0 0 {name=l2357 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 4290 0 0 {name=l2358 sig_type=std_logic lab=WL_18_II}
C {devices/lab_pin.sym} 5680 4230 0 0 {name=l2359 sig_type=std_logic lab=PL_18_II}
C {devices/lab_pin.sym} 5680 4290 0 0 {name=l2360 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 4260 0 0 {name=Xc_18_14
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 4230 0 0 {name=l2361 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 4290 0 0 {name=l2362 sig_type=std_logic lab=WL_18_II}
C {devices/lab_pin.sym} 6080 4230 0 0 {name=l2363 sig_type=std_logic lab=PL_18_II}
C {devices/lab_pin.sym} 6080 4290 0 0 {name=l2364 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 4260 0 0 {name=Xc_18_15
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 4230 0 0 {name=l2365 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 4290 0 0 {name=l2366 sig_type=std_logic lab=WL_18_II}
C {devices/lab_pin.sym} 6480 4230 0 0 {name=l2367 sig_type=std_logic lab=PL_18_II}
C {devices/lab_pin.sym} 6480 4290 0 0 {name=l2368 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 4260 0 0 {name=Xc_18_16
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 4230 0 0 {name=l2369 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 4290 0 0 {name=l2370 sig_type=std_logic lab=WL_18_II}
C {devices/lab_pin.sym} 6880 4230 0 0 {name=l2371 sig_type=std_logic lab=PL_18_II}
C {devices/lab_pin.sym} 6880 4290 0 0 {name=l2372 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 4260 0 0 {name=Xc_18_17
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 4230 0 0 {name=l2373 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 4290 0 0 {name=l2374 sig_type=std_logic lab=WL_18_II}
C {devices/lab_pin.sym} 7280 4230 0 0 {name=l2375 sig_type=std_logic lab=PL_18_II}
C {devices/lab_pin.sym} 7280 4290 0 0 {name=l2376 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 4260 0 0 {name=Xc_18_18
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 4230 0 0 {name=l2377 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 4290 0 0 {name=l2378 sig_type=std_logic lab=WL_18_II}
C {devices/lab_pin.sym} 7680 4230 0 0 {name=l2379 sig_type=std_logic lab=PL_18_II}
C {devices/lab_pin.sym} 7680 4290 0 0 {name=l2380 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 4260 0 0 {name=Xc_18_19
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 4230 0 0 {name=l2381 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 4290 0 0 {name=l2382 sig_type=std_logic lab=WL_18_II}
C {devices/lab_pin.sym} 8080 4230 0 0 {name=l2383 sig_type=std_logic lab=PL_18_II}
C {devices/lab_pin.sym} 8080 4290 0 0 {name=l2384 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 4260 0 0 {name=Xc_18_20
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 4230 0 0 {name=l2385 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 4290 0 0 {name=l2386 sig_type=std_logic lab=WL_18_II}
C {devices/lab_pin.sym} 8480 4230 0 0 {name=l2387 sig_type=std_logic lab=PL_18_II}
C {devices/lab_pin.sym} 8480 4290 0 0 {name=l2388 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 4260 0 0 {name=Xc_18_21
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 4230 0 0 {name=l2389 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 4290 0 0 {name=l2390 sig_type=std_logic lab=WL_18_II}
C {devices/lab_pin.sym} 8880 4230 0 0 {name=l2391 sig_type=std_logic lab=PL_18_II}
C {devices/lab_pin.sym} 8880 4290 0 0 {name=l2392 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 4260 0 0 {name=Xc_18_22
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 4230 0 0 {name=l2393 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 4290 0 0 {name=l2394 sig_type=std_logic lab=WL_18_III}
C {devices/lab_pin.sym} 9280 4230 0 0 {name=l2395 sig_type=std_logic lab=PL_18_III}
C {devices/lab_pin.sym} 9280 4290 0 0 {name=l2396 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 4260 0 0 {name=Xc_18_23
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 4230 0 0 {name=l2397 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 4290 0 0 {name=l2398 sig_type=std_logic lab=WL_18_III}
C {devices/lab_pin.sym} 9680 4230 0 0 {name=l2399 sig_type=std_logic lab=PL_18_III}
C {devices/lab_pin.sym} 9680 4290 0 0 {name=l2400 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 4260 0 0 {name=Xc_18_24
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 4230 0 0 {name=l2401 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 4290 0 0 {name=l2402 sig_type=std_logic lab=WL_18_III}
C {devices/lab_pin.sym} 10080 4230 0 0 {name=l2403 sig_type=std_logic lab=PL_18_III}
C {devices/lab_pin.sym} 10080 4290 0 0 {name=l2404 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 4260 0 0 {name=Xc_18_25
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 4230 0 0 {name=l2405 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 4290 0 0 {name=l2406 sig_type=std_logic lab=WL_18_III}
C {devices/lab_pin.sym} 10480 4230 0 0 {name=l2407 sig_type=std_logic lab=PL_18_III}
C {devices/lab_pin.sym} 10480 4290 0 0 {name=l2408 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 4260 0 0 {name=Xc_18_26
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 4230 0 0 {name=l2409 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 4290 0 0 {name=l2410 sig_type=std_logic lab=WL_18_III}
C {devices/lab_pin.sym} 10880 4230 0 0 {name=l2411 sig_type=std_logic lab=PL_18_III}
C {devices/lab_pin.sym} 10880 4290 0 0 {name=l2412 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 4260 0 0 {name=Xc_18_27
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 4230 0 0 {name=l2413 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 4290 0 0 {name=l2414 sig_type=std_logic lab=WL_18_III}
C {devices/lab_pin.sym} 11280 4230 0 0 {name=l2415 sig_type=std_logic lab=PL_18_III}
C {devices/lab_pin.sym} 11280 4290 0 0 {name=l2416 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 4260 0 0 {name=Xc_18_28
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 4230 0 0 {name=l2417 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 4290 0 0 {name=l2418 sig_type=std_logic lab=WL_18_III}
C {devices/lab_pin.sym} 11680 4230 0 0 {name=l2419 sig_type=std_logic lab=PL_18_III}
C {devices/lab_pin.sym} 11680 4290 0 0 {name=l2420 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 4260 0 0 {name=Xc_18_29
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 4230 0 0 {name=l2421 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 4290 0 0 {name=l2422 sig_type=std_logic lab=WL_18_III}
C {devices/lab_pin.sym} 12080 4230 0 0 {name=l2423 sig_type=std_logic lab=PL_18_III}
C {devices/lab_pin.sym} 12080 4290 0 0 {name=l2424 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 4260 0 0 {name=Xc_18_30
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 4230 0 0 {name=l2425 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 4290 0 0 {name=l2426 sig_type=std_logic lab=WL_18_III}
C {devices/lab_pin.sym} 12480 4230 0 0 {name=l2427 sig_type=std_logic lab=PL_18_III}
C {devices/lab_pin.sym} 12480 4290 0 0 {name=l2428 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 4260 0 0 {name=Xc_18_31
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 4230 0 0 {name=l2429 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 4290 0 0 {name=l2430 sig_type=std_logic lab=WL_18_III}
C {devices/lab_pin.sym} 12880 4230 0 0 {name=l2431 sig_type=std_logic lab=PL_18_III}
C {devices/lab_pin.sym} 12880 4290 0 0 {name=l2432 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 4480 0 0 {name=Xc_19_0
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 4450 0 0 {name=l2433 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 4510 0 0 {name=l2434 sig_type=std_logic lab=WL_19_I}
C {devices/lab_pin.sym} 480 4450 0 0 {name=l2435 sig_type=std_logic lab=PL_19_I}
C {devices/lab_pin.sym} 480 4510 0 0 {name=l2436 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 4480 0 0 {name=Xc_19_1
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 4450 0 0 {name=l2437 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 4510 0 0 {name=l2438 sig_type=std_logic lab=WL_19_I}
C {devices/lab_pin.sym} 880 4450 0 0 {name=l2439 sig_type=std_logic lab=PL_19_I}
C {devices/lab_pin.sym} 880 4510 0 0 {name=l2440 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 4480 0 0 {name=Xc_19_2
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 4450 0 0 {name=l2441 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 4510 0 0 {name=l2442 sig_type=std_logic lab=WL_19_I}
C {devices/lab_pin.sym} 1280 4450 0 0 {name=l2443 sig_type=std_logic lab=PL_19_I}
C {devices/lab_pin.sym} 1280 4510 0 0 {name=l2444 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 4480 0 0 {name=Xc_19_3
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 4450 0 0 {name=l2445 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 4510 0 0 {name=l2446 sig_type=std_logic lab=WL_19_I}
C {devices/lab_pin.sym} 1680 4450 0 0 {name=l2447 sig_type=std_logic lab=PL_19_I}
C {devices/lab_pin.sym} 1680 4510 0 0 {name=l2448 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 4480 0 0 {name=Xc_19_4
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 4450 0 0 {name=l2449 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 4510 0 0 {name=l2450 sig_type=std_logic lab=WL_19_I}
C {devices/lab_pin.sym} 2080 4450 0 0 {name=l2451 sig_type=std_logic lab=PL_19_I}
C {devices/lab_pin.sym} 2080 4510 0 0 {name=l2452 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 4480 0 0 {name=Xc_19_5
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 4450 0 0 {name=l2453 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 4510 0 0 {name=l2454 sig_type=std_logic lab=WL_19_I}
C {devices/lab_pin.sym} 2480 4450 0 0 {name=l2455 sig_type=std_logic lab=PL_19_I}
C {devices/lab_pin.sym} 2480 4510 0 0 {name=l2456 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 4480 0 0 {name=Xc_19_6
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 4450 0 0 {name=l2457 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 4510 0 0 {name=l2458 sig_type=std_logic lab=WL_19_I}
C {devices/lab_pin.sym} 2880 4450 0 0 {name=l2459 sig_type=std_logic lab=PL_19_I}
C {devices/lab_pin.sym} 2880 4510 0 0 {name=l2460 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 4480 0 0 {name=Xc_19_7
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 4450 0 0 {name=l2461 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 4510 0 0 {name=l2462 sig_type=std_logic lab=WL_19_I}
C {devices/lab_pin.sym} 3280 4450 0 0 {name=l2463 sig_type=std_logic lab=PL_19_I}
C {devices/lab_pin.sym} 3280 4510 0 0 {name=l2464 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 4480 0 0 {name=Xc_19_8
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 4450 0 0 {name=l2465 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 4510 0 0 {name=l2466 sig_type=std_logic lab=WL_19_I}
C {devices/lab_pin.sym} 3680 4450 0 0 {name=l2467 sig_type=std_logic lab=PL_19_I}
C {devices/lab_pin.sym} 3680 4510 0 0 {name=l2468 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 4480 0 0 {name=Xc_19_9
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 4450 0 0 {name=l2469 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 4510 0 0 {name=l2470 sig_type=std_logic lab=WL_19_I}
C {devices/lab_pin.sym} 4080 4450 0 0 {name=l2471 sig_type=std_logic lab=PL_19_I}
C {devices/lab_pin.sym} 4080 4510 0 0 {name=l2472 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 4480 0 0 {name=Xc_19_10
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 4450 0 0 {name=l2473 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 4510 0 0 {name=l2474 sig_type=std_logic lab=WL_19_I}
C {devices/lab_pin.sym} 4480 4450 0 0 {name=l2475 sig_type=std_logic lab=PL_19_I}
C {devices/lab_pin.sym} 4480 4510 0 0 {name=l2476 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 4480 0 0 {name=Xc_19_11
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 4450 0 0 {name=l2477 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 4510 0 0 {name=l2478 sig_type=std_logic lab=WL_19_II}
C {devices/lab_pin.sym} 4880 4450 0 0 {name=l2479 sig_type=std_logic lab=PL_19_II}
C {devices/lab_pin.sym} 4880 4510 0 0 {name=l2480 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 4480 0 0 {name=Xc_19_12
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 4450 0 0 {name=l2481 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 4510 0 0 {name=l2482 sig_type=std_logic lab=WL_19_II}
C {devices/lab_pin.sym} 5280 4450 0 0 {name=l2483 sig_type=std_logic lab=PL_19_II}
C {devices/lab_pin.sym} 5280 4510 0 0 {name=l2484 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 4480 0 0 {name=Xc_19_13
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 4450 0 0 {name=l2485 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 4510 0 0 {name=l2486 sig_type=std_logic lab=WL_19_II}
C {devices/lab_pin.sym} 5680 4450 0 0 {name=l2487 sig_type=std_logic lab=PL_19_II}
C {devices/lab_pin.sym} 5680 4510 0 0 {name=l2488 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 4480 0 0 {name=Xc_19_14
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 4450 0 0 {name=l2489 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 4510 0 0 {name=l2490 sig_type=std_logic lab=WL_19_II}
C {devices/lab_pin.sym} 6080 4450 0 0 {name=l2491 sig_type=std_logic lab=PL_19_II}
C {devices/lab_pin.sym} 6080 4510 0 0 {name=l2492 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 4480 0 0 {name=Xc_19_15
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 4450 0 0 {name=l2493 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 4510 0 0 {name=l2494 sig_type=std_logic lab=WL_19_II}
C {devices/lab_pin.sym} 6480 4450 0 0 {name=l2495 sig_type=std_logic lab=PL_19_II}
C {devices/lab_pin.sym} 6480 4510 0 0 {name=l2496 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 4480 0 0 {name=Xc_19_16
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 4450 0 0 {name=l2497 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 4510 0 0 {name=l2498 sig_type=std_logic lab=WL_19_II}
C {devices/lab_pin.sym} 6880 4450 0 0 {name=l2499 sig_type=std_logic lab=PL_19_II}
C {devices/lab_pin.sym} 6880 4510 0 0 {name=l2500 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 4480 0 0 {name=Xc_19_17
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 4450 0 0 {name=l2501 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 4510 0 0 {name=l2502 sig_type=std_logic lab=WL_19_II}
C {devices/lab_pin.sym} 7280 4450 0 0 {name=l2503 sig_type=std_logic lab=PL_19_II}
C {devices/lab_pin.sym} 7280 4510 0 0 {name=l2504 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 4480 0 0 {name=Xc_19_18
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 4450 0 0 {name=l2505 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 4510 0 0 {name=l2506 sig_type=std_logic lab=WL_19_II}
C {devices/lab_pin.sym} 7680 4450 0 0 {name=l2507 sig_type=std_logic lab=PL_19_II}
C {devices/lab_pin.sym} 7680 4510 0 0 {name=l2508 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 4480 0 0 {name=Xc_19_19
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 4450 0 0 {name=l2509 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 4510 0 0 {name=l2510 sig_type=std_logic lab=WL_19_II}
C {devices/lab_pin.sym} 8080 4450 0 0 {name=l2511 sig_type=std_logic lab=PL_19_II}
C {devices/lab_pin.sym} 8080 4510 0 0 {name=l2512 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 4480 0 0 {name=Xc_19_20
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 4450 0 0 {name=l2513 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 4510 0 0 {name=l2514 sig_type=std_logic lab=WL_19_II}
C {devices/lab_pin.sym} 8480 4450 0 0 {name=l2515 sig_type=std_logic lab=PL_19_II}
C {devices/lab_pin.sym} 8480 4510 0 0 {name=l2516 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 4480 0 0 {name=Xc_19_21
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 4450 0 0 {name=l2517 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 4510 0 0 {name=l2518 sig_type=std_logic lab=WL_19_II}
C {devices/lab_pin.sym} 8880 4450 0 0 {name=l2519 sig_type=std_logic lab=PL_19_II}
C {devices/lab_pin.sym} 8880 4510 0 0 {name=l2520 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 4480 0 0 {name=Xc_19_22
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 4450 0 0 {name=l2521 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 4510 0 0 {name=l2522 sig_type=std_logic lab=WL_19_III}
C {devices/lab_pin.sym} 9280 4450 0 0 {name=l2523 sig_type=std_logic lab=PL_19_III}
C {devices/lab_pin.sym} 9280 4510 0 0 {name=l2524 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 4480 0 0 {name=Xc_19_23
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 4450 0 0 {name=l2525 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 4510 0 0 {name=l2526 sig_type=std_logic lab=WL_19_III}
C {devices/lab_pin.sym} 9680 4450 0 0 {name=l2527 sig_type=std_logic lab=PL_19_III}
C {devices/lab_pin.sym} 9680 4510 0 0 {name=l2528 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 4480 0 0 {name=Xc_19_24
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 4450 0 0 {name=l2529 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 4510 0 0 {name=l2530 sig_type=std_logic lab=WL_19_III}
C {devices/lab_pin.sym} 10080 4450 0 0 {name=l2531 sig_type=std_logic lab=PL_19_III}
C {devices/lab_pin.sym} 10080 4510 0 0 {name=l2532 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 4480 0 0 {name=Xc_19_25
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 4450 0 0 {name=l2533 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 4510 0 0 {name=l2534 sig_type=std_logic lab=WL_19_III}
C {devices/lab_pin.sym} 10480 4450 0 0 {name=l2535 sig_type=std_logic lab=PL_19_III}
C {devices/lab_pin.sym} 10480 4510 0 0 {name=l2536 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 4480 0 0 {name=Xc_19_26
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 4450 0 0 {name=l2537 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 4510 0 0 {name=l2538 sig_type=std_logic lab=WL_19_III}
C {devices/lab_pin.sym} 10880 4450 0 0 {name=l2539 sig_type=std_logic lab=PL_19_III}
C {devices/lab_pin.sym} 10880 4510 0 0 {name=l2540 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 4480 0 0 {name=Xc_19_27
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 4450 0 0 {name=l2541 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 4510 0 0 {name=l2542 sig_type=std_logic lab=WL_19_III}
C {devices/lab_pin.sym} 11280 4450 0 0 {name=l2543 sig_type=std_logic lab=PL_19_III}
C {devices/lab_pin.sym} 11280 4510 0 0 {name=l2544 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 4480 0 0 {name=Xc_19_28
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 4450 0 0 {name=l2545 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 4510 0 0 {name=l2546 sig_type=std_logic lab=WL_19_III}
C {devices/lab_pin.sym} 11680 4450 0 0 {name=l2547 sig_type=std_logic lab=PL_19_III}
C {devices/lab_pin.sym} 11680 4510 0 0 {name=l2548 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 4480 0 0 {name=Xc_19_29
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 4450 0 0 {name=l2549 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 4510 0 0 {name=l2550 sig_type=std_logic lab=WL_19_III}
C {devices/lab_pin.sym} 12080 4450 0 0 {name=l2551 sig_type=std_logic lab=PL_19_III}
C {devices/lab_pin.sym} 12080 4510 0 0 {name=l2552 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 4480 0 0 {name=Xc_19_30
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 4450 0 0 {name=l2553 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 4510 0 0 {name=l2554 sig_type=std_logic lab=WL_19_III}
C {devices/lab_pin.sym} 12480 4450 0 0 {name=l2555 sig_type=std_logic lab=PL_19_III}
C {devices/lab_pin.sym} 12480 4510 0 0 {name=l2556 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 4480 0 0 {name=Xc_19_31
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 4450 0 0 {name=l2557 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 4510 0 0 {name=l2558 sig_type=std_logic lab=WL_19_III}
C {devices/lab_pin.sym} 12880 4450 0 0 {name=l2559 sig_type=std_logic lab=PL_19_III}
C {devices/lab_pin.sym} 12880 4510 0 0 {name=l2560 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 4700 0 0 {name=Xc_20_0
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 4670 0 0 {name=l2561 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 4730 0 0 {name=l2562 sig_type=std_logic lab=WL_20_I}
C {devices/lab_pin.sym} 480 4670 0 0 {name=l2563 sig_type=std_logic lab=PL_20_I}
C {devices/lab_pin.sym} 480 4730 0 0 {name=l2564 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 4700 0 0 {name=Xc_20_1
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 4670 0 0 {name=l2565 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 4730 0 0 {name=l2566 sig_type=std_logic lab=WL_20_I}
C {devices/lab_pin.sym} 880 4670 0 0 {name=l2567 sig_type=std_logic lab=PL_20_I}
C {devices/lab_pin.sym} 880 4730 0 0 {name=l2568 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 4700 0 0 {name=Xc_20_2
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 4670 0 0 {name=l2569 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 4730 0 0 {name=l2570 sig_type=std_logic lab=WL_20_I}
C {devices/lab_pin.sym} 1280 4670 0 0 {name=l2571 sig_type=std_logic lab=PL_20_I}
C {devices/lab_pin.sym} 1280 4730 0 0 {name=l2572 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 4700 0 0 {name=Xc_20_3
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 4670 0 0 {name=l2573 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 4730 0 0 {name=l2574 sig_type=std_logic lab=WL_20_I}
C {devices/lab_pin.sym} 1680 4670 0 0 {name=l2575 sig_type=std_logic lab=PL_20_I}
C {devices/lab_pin.sym} 1680 4730 0 0 {name=l2576 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 4700 0 0 {name=Xc_20_4
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 4670 0 0 {name=l2577 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 4730 0 0 {name=l2578 sig_type=std_logic lab=WL_20_I}
C {devices/lab_pin.sym} 2080 4670 0 0 {name=l2579 sig_type=std_logic lab=PL_20_I}
C {devices/lab_pin.sym} 2080 4730 0 0 {name=l2580 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 4700 0 0 {name=Xc_20_5
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 4670 0 0 {name=l2581 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 4730 0 0 {name=l2582 sig_type=std_logic lab=WL_20_I}
C {devices/lab_pin.sym} 2480 4670 0 0 {name=l2583 sig_type=std_logic lab=PL_20_I}
C {devices/lab_pin.sym} 2480 4730 0 0 {name=l2584 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 4700 0 0 {name=Xc_20_6
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 4670 0 0 {name=l2585 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 4730 0 0 {name=l2586 sig_type=std_logic lab=WL_20_I}
C {devices/lab_pin.sym} 2880 4670 0 0 {name=l2587 sig_type=std_logic lab=PL_20_I}
C {devices/lab_pin.sym} 2880 4730 0 0 {name=l2588 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 4700 0 0 {name=Xc_20_7
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 4670 0 0 {name=l2589 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 4730 0 0 {name=l2590 sig_type=std_logic lab=WL_20_I}
C {devices/lab_pin.sym} 3280 4670 0 0 {name=l2591 sig_type=std_logic lab=PL_20_I}
C {devices/lab_pin.sym} 3280 4730 0 0 {name=l2592 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 4700 0 0 {name=Xc_20_8
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 4670 0 0 {name=l2593 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 4730 0 0 {name=l2594 sig_type=std_logic lab=WL_20_I}
C {devices/lab_pin.sym} 3680 4670 0 0 {name=l2595 sig_type=std_logic lab=PL_20_I}
C {devices/lab_pin.sym} 3680 4730 0 0 {name=l2596 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 4700 0 0 {name=Xc_20_9
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 4670 0 0 {name=l2597 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 4730 0 0 {name=l2598 sig_type=std_logic lab=WL_20_I}
C {devices/lab_pin.sym} 4080 4670 0 0 {name=l2599 sig_type=std_logic lab=PL_20_I}
C {devices/lab_pin.sym} 4080 4730 0 0 {name=l2600 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 4700 0 0 {name=Xc_20_10
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 4670 0 0 {name=l2601 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 4730 0 0 {name=l2602 sig_type=std_logic lab=WL_20_I}
C {devices/lab_pin.sym} 4480 4670 0 0 {name=l2603 sig_type=std_logic lab=PL_20_I}
C {devices/lab_pin.sym} 4480 4730 0 0 {name=l2604 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 4700 0 0 {name=Xc_20_11
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 4670 0 0 {name=l2605 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 4730 0 0 {name=l2606 sig_type=std_logic lab=WL_20_II}
C {devices/lab_pin.sym} 4880 4670 0 0 {name=l2607 sig_type=std_logic lab=PL_20_II}
C {devices/lab_pin.sym} 4880 4730 0 0 {name=l2608 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 4700 0 0 {name=Xc_20_12
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 4670 0 0 {name=l2609 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 4730 0 0 {name=l2610 sig_type=std_logic lab=WL_20_II}
C {devices/lab_pin.sym} 5280 4670 0 0 {name=l2611 sig_type=std_logic lab=PL_20_II}
C {devices/lab_pin.sym} 5280 4730 0 0 {name=l2612 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 4700 0 0 {name=Xc_20_13
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 4670 0 0 {name=l2613 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 4730 0 0 {name=l2614 sig_type=std_logic lab=WL_20_II}
C {devices/lab_pin.sym} 5680 4670 0 0 {name=l2615 sig_type=std_logic lab=PL_20_II}
C {devices/lab_pin.sym} 5680 4730 0 0 {name=l2616 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 4700 0 0 {name=Xc_20_14
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 4670 0 0 {name=l2617 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 4730 0 0 {name=l2618 sig_type=std_logic lab=WL_20_II}
C {devices/lab_pin.sym} 6080 4670 0 0 {name=l2619 sig_type=std_logic lab=PL_20_II}
C {devices/lab_pin.sym} 6080 4730 0 0 {name=l2620 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 4700 0 0 {name=Xc_20_15
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 4670 0 0 {name=l2621 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 4730 0 0 {name=l2622 sig_type=std_logic lab=WL_20_II}
C {devices/lab_pin.sym} 6480 4670 0 0 {name=l2623 sig_type=std_logic lab=PL_20_II}
C {devices/lab_pin.sym} 6480 4730 0 0 {name=l2624 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 4700 0 0 {name=Xc_20_16
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 4670 0 0 {name=l2625 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 4730 0 0 {name=l2626 sig_type=std_logic lab=WL_20_II}
C {devices/lab_pin.sym} 6880 4670 0 0 {name=l2627 sig_type=std_logic lab=PL_20_II}
C {devices/lab_pin.sym} 6880 4730 0 0 {name=l2628 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 4700 0 0 {name=Xc_20_17
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 4670 0 0 {name=l2629 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 4730 0 0 {name=l2630 sig_type=std_logic lab=WL_20_II}
C {devices/lab_pin.sym} 7280 4670 0 0 {name=l2631 sig_type=std_logic lab=PL_20_II}
C {devices/lab_pin.sym} 7280 4730 0 0 {name=l2632 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 4700 0 0 {name=Xc_20_18
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 4670 0 0 {name=l2633 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 4730 0 0 {name=l2634 sig_type=std_logic lab=WL_20_II}
C {devices/lab_pin.sym} 7680 4670 0 0 {name=l2635 sig_type=std_logic lab=PL_20_II}
C {devices/lab_pin.sym} 7680 4730 0 0 {name=l2636 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 4700 0 0 {name=Xc_20_19
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 4670 0 0 {name=l2637 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 4730 0 0 {name=l2638 sig_type=std_logic lab=WL_20_II}
C {devices/lab_pin.sym} 8080 4670 0 0 {name=l2639 sig_type=std_logic lab=PL_20_II}
C {devices/lab_pin.sym} 8080 4730 0 0 {name=l2640 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 4700 0 0 {name=Xc_20_20
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 4670 0 0 {name=l2641 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 4730 0 0 {name=l2642 sig_type=std_logic lab=WL_20_II}
C {devices/lab_pin.sym} 8480 4670 0 0 {name=l2643 sig_type=std_logic lab=PL_20_II}
C {devices/lab_pin.sym} 8480 4730 0 0 {name=l2644 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 4700 0 0 {name=Xc_20_21
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 4670 0 0 {name=l2645 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 4730 0 0 {name=l2646 sig_type=std_logic lab=WL_20_II}
C {devices/lab_pin.sym} 8880 4670 0 0 {name=l2647 sig_type=std_logic lab=PL_20_II}
C {devices/lab_pin.sym} 8880 4730 0 0 {name=l2648 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 4700 0 0 {name=Xc_20_22
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 4670 0 0 {name=l2649 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 4730 0 0 {name=l2650 sig_type=std_logic lab=WL_20_III}
C {devices/lab_pin.sym} 9280 4670 0 0 {name=l2651 sig_type=std_logic lab=PL_20_III}
C {devices/lab_pin.sym} 9280 4730 0 0 {name=l2652 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 4700 0 0 {name=Xc_20_23
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 4670 0 0 {name=l2653 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 4730 0 0 {name=l2654 sig_type=std_logic lab=WL_20_III}
C {devices/lab_pin.sym} 9680 4670 0 0 {name=l2655 sig_type=std_logic lab=PL_20_III}
C {devices/lab_pin.sym} 9680 4730 0 0 {name=l2656 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 4700 0 0 {name=Xc_20_24
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 4670 0 0 {name=l2657 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 4730 0 0 {name=l2658 sig_type=std_logic lab=WL_20_III}
C {devices/lab_pin.sym} 10080 4670 0 0 {name=l2659 sig_type=std_logic lab=PL_20_III}
C {devices/lab_pin.sym} 10080 4730 0 0 {name=l2660 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 4700 0 0 {name=Xc_20_25
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 4670 0 0 {name=l2661 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 4730 0 0 {name=l2662 sig_type=std_logic lab=WL_20_III}
C {devices/lab_pin.sym} 10480 4670 0 0 {name=l2663 sig_type=std_logic lab=PL_20_III}
C {devices/lab_pin.sym} 10480 4730 0 0 {name=l2664 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 4700 0 0 {name=Xc_20_26
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 4670 0 0 {name=l2665 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 4730 0 0 {name=l2666 sig_type=std_logic lab=WL_20_III}
C {devices/lab_pin.sym} 10880 4670 0 0 {name=l2667 sig_type=std_logic lab=PL_20_III}
C {devices/lab_pin.sym} 10880 4730 0 0 {name=l2668 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 4700 0 0 {name=Xc_20_27
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 4670 0 0 {name=l2669 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 4730 0 0 {name=l2670 sig_type=std_logic lab=WL_20_III}
C {devices/lab_pin.sym} 11280 4670 0 0 {name=l2671 sig_type=std_logic lab=PL_20_III}
C {devices/lab_pin.sym} 11280 4730 0 0 {name=l2672 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 4700 0 0 {name=Xc_20_28
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 4670 0 0 {name=l2673 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 4730 0 0 {name=l2674 sig_type=std_logic lab=WL_20_III}
C {devices/lab_pin.sym} 11680 4670 0 0 {name=l2675 sig_type=std_logic lab=PL_20_III}
C {devices/lab_pin.sym} 11680 4730 0 0 {name=l2676 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 4700 0 0 {name=Xc_20_29
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 4670 0 0 {name=l2677 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 4730 0 0 {name=l2678 sig_type=std_logic lab=WL_20_III}
C {devices/lab_pin.sym} 12080 4670 0 0 {name=l2679 sig_type=std_logic lab=PL_20_III}
C {devices/lab_pin.sym} 12080 4730 0 0 {name=l2680 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 4700 0 0 {name=Xc_20_30
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 4670 0 0 {name=l2681 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 4730 0 0 {name=l2682 sig_type=std_logic lab=WL_20_III}
C {devices/lab_pin.sym} 12480 4670 0 0 {name=l2683 sig_type=std_logic lab=PL_20_III}
C {devices/lab_pin.sym} 12480 4730 0 0 {name=l2684 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 4700 0 0 {name=Xc_20_31
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 4670 0 0 {name=l2685 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 4730 0 0 {name=l2686 sig_type=std_logic lab=WL_20_III}
C {devices/lab_pin.sym} 12880 4670 0 0 {name=l2687 sig_type=std_logic lab=PL_20_III}
C {devices/lab_pin.sym} 12880 4730 0 0 {name=l2688 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 4920 0 0 {name=Xc_21_0
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 4890 0 0 {name=l2689 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 4950 0 0 {name=l2690 sig_type=std_logic lab=WL_21_I}
C {devices/lab_pin.sym} 480 4890 0 0 {name=l2691 sig_type=std_logic lab=PL_21_I}
C {devices/lab_pin.sym} 480 4950 0 0 {name=l2692 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 4920 0 0 {name=Xc_21_1
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 4890 0 0 {name=l2693 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 4950 0 0 {name=l2694 sig_type=std_logic lab=WL_21_I}
C {devices/lab_pin.sym} 880 4890 0 0 {name=l2695 sig_type=std_logic lab=PL_21_I}
C {devices/lab_pin.sym} 880 4950 0 0 {name=l2696 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 4920 0 0 {name=Xc_21_2
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 4890 0 0 {name=l2697 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 4950 0 0 {name=l2698 sig_type=std_logic lab=WL_21_I}
C {devices/lab_pin.sym} 1280 4890 0 0 {name=l2699 sig_type=std_logic lab=PL_21_I}
C {devices/lab_pin.sym} 1280 4950 0 0 {name=l2700 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 4920 0 0 {name=Xc_21_3
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 4890 0 0 {name=l2701 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 4950 0 0 {name=l2702 sig_type=std_logic lab=WL_21_I}
C {devices/lab_pin.sym} 1680 4890 0 0 {name=l2703 sig_type=std_logic lab=PL_21_I}
C {devices/lab_pin.sym} 1680 4950 0 0 {name=l2704 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 4920 0 0 {name=Xc_21_4
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 4890 0 0 {name=l2705 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 4950 0 0 {name=l2706 sig_type=std_logic lab=WL_21_I}
C {devices/lab_pin.sym} 2080 4890 0 0 {name=l2707 sig_type=std_logic lab=PL_21_I}
C {devices/lab_pin.sym} 2080 4950 0 0 {name=l2708 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 4920 0 0 {name=Xc_21_5
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 4890 0 0 {name=l2709 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 4950 0 0 {name=l2710 sig_type=std_logic lab=WL_21_I}
C {devices/lab_pin.sym} 2480 4890 0 0 {name=l2711 sig_type=std_logic lab=PL_21_I}
C {devices/lab_pin.sym} 2480 4950 0 0 {name=l2712 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 4920 0 0 {name=Xc_21_6
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 4890 0 0 {name=l2713 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 4950 0 0 {name=l2714 sig_type=std_logic lab=WL_21_I}
C {devices/lab_pin.sym} 2880 4890 0 0 {name=l2715 sig_type=std_logic lab=PL_21_I}
C {devices/lab_pin.sym} 2880 4950 0 0 {name=l2716 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 4920 0 0 {name=Xc_21_7
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 4890 0 0 {name=l2717 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 4950 0 0 {name=l2718 sig_type=std_logic lab=WL_21_I}
C {devices/lab_pin.sym} 3280 4890 0 0 {name=l2719 sig_type=std_logic lab=PL_21_I}
C {devices/lab_pin.sym} 3280 4950 0 0 {name=l2720 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 4920 0 0 {name=Xc_21_8
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 4890 0 0 {name=l2721 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 4950 0 0 {name=l2722 sig_type=std_logic lab=WL_21_I}
C {devices/lab_pin.sym} 3680 4890 0 0 {name=l2723 sig_type=std_logic lab=PL_21_I}
C {devices/lab_pin.sym} 3680 4950 0 0 {name=l2724 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 4920 0 0 {name=Xc_21_9
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 4890 0 0 {name=l2725 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 4950 0 0 {name=l2726 sig_type=std_logic lab=WL_21_I}
C {devices/lab_pin.sym} 4080 4890 0 0 {name=l2727 sig_type=std_logic lab=PL_21_I}
C {devices/lab_pin.sym} 4080 4950 0 0 {name=l2728 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 4920 0 0 {name=Xc_21_10
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 4890 0 0 {name=l2729 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 4950 0 0 {name=l2730 sig_type=std_logic lab=WL_21_I}
C {devices/lab_pin.sym} 4480 4890 0 0 {name=l2731 sig_type=std_logic lab=PL_21_I}
C {devices/lab_pin.sym} 4480 4950 0 0 {name=l2732 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 4920 0 0 {name=Xc_21_11
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 4890 0 0 {name=l2733 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 4950 0 0 {name=l2734 sig_type=std_logic lab=WL_21_II}
C {devices/lab_pin.sym} 4880 4890 0 0 {name=l2735 sig_type=std_logic lab=PL_21_II}
C {devices/lab_pin.sym} 4880 4950 0 0 {name=l2736 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 4920 0 0 {name=Xc_21_12
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 4890 0 0 {name=l2737 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 4950 0 0 {name=l2738 sig_type=std_logic lab=WL_21_II}
C {devices/lab_pin.sym} 5280 4890 0 0 {name=l2739 sig_type=std_logic lab=PL_21_II}
C {devices/lab_pin.sym} 5280 4950 0 0 {name=l2740 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 4920 0 0 {name=Xc_21_13
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 4890 0 0 {name=l2741 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 4950 0 0 {name=l2742 sig_type=std_logic lab=WL_21_II}
C {devices/lab_pin.sym} 5680 4890 0 0 {name=l2743 sig_type=std_logic lab=PL_21_II}
C {devices/lab_pin.sym} 5680 4950 0 0 {name=l2744 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 4920 0 0 {name=Xc_21_14
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 4890 0 0 {name=l2745 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 4950 0 0 {name=l2746 sig_type=std_logic lab=WL_21_II}
C {devices/lab_pin.sym} 6080 4890 0 0 {name=l2747 sig_type=std_logic lab=PL_21_II}
C {devices/lab_pin.sym} 6080 4950 0 0 {name=l2748 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 4920 0 0 {name=Xc_21_15
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 4890 0 0 {name=l2749 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 4950 0 0 {name=l2750 sig_type=std_logic lab=WL_21_II}
C {devices/lab_pin.sym} 6480 4890 0 0 {name=l2751 sig_type=std_logic lab=PL_21_II}
C {devices/lab_pin.sym} 6480 4950 0 0 {name=l2752 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 4920 0 0 {name=Xc_21_16
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 4890 0 0 {name=l2753 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 4950 0 0 {name=l2754 sig_type=std_logic lab=WL_21_II}
C {devices/lab_pin.sym} 6880 4890 0 0 {name=l2755 sig_type=std_logic lab=PL_21_II}
C {devices/lab_pin.sym} 6880 4950 0 0 {name=l2756 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 4920 0 0 {name=Xc_21_17
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 4890 0 0 {name=l2757 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 4950 0 0 {name=l2758 sig_type=std_logic lab=WL_21_II}
C {devices/lab_pin.sym} 7280 4890 0 0 {name=l2759 sig_type=std_logic lab=PL_21_II}
C {devices/lab_pin.sym} 7280 4950 0 0 {name=l2760 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 4920 0 0 {name=Xc_21_18
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 4890 0 0 {name=l2761 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 4950 0 0 {name=l2762 sig_type=std_logic lab=WL_21_II}
C {devices/lab_pin.sym} 7680 4890 0 0 {name=l2763 sig_type=std_logic lab=PL_21_II}
C {devices/lab_pin.sym} 7680 4950 0 0 {name=l2764 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 4920 0 0 {name=Xc_21_19
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 4890 0 0 {name=l2765 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 4950 0 0 {name=l2766 sig_type=std_logic lab=WL_21_II}
C {devices/lab_pin.sym} 8080 4890 0 0 {name=l2767 sig_type=std_logic lab=PL_21_II}
C {devices/lab_pin.sym} 8080 4950 0 0 {name=l2768 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 4920 0 0 {name=Xc_21_20
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 4890 0 0 {name=l2769 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 4950 0 0 {name=l2770 sig_type=std_logic lab=WL_21_II}
C {devices/lab_pin.sym} 8480 4890 0 0 {name=l2771 sig_type=std_logic lab=PL_21_II}
C {devices/lab_pin.sym} 8480 4950 0 0 {name=l2772 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 4920 0 0 {name=Xc_21_21
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 4890 0 0 {name=l2773 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 4950 0 0 {name=l2774 sig_type=std_logic lab=WL_21_II}
C {devices/lab_pin.sym} 8880 4890 0 0 {name=l2775 sig_type=std_logic lab=PL_21_II}
C {devices/lab_pin.sym} 8880 4950 0 0 {name=l2776 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 4920 0 0 {name=Xc_21_22
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 4890 0 0 {name=l2777 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 4950 0 0 {name=l2778 sig_type=std_logic lab=WL_21_III}
C {devices/lab_pin.sym} 9280 4890 0 0 {name=l2779 sig_type=std_logic lab=PL_21_III}
C {devices/lab_pin.sym} 9280 4950 0 0 {name=l2780 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 4920 0 0 {name=Xc_21_23
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 4890 0 0 {name=l2781 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 4950 0 0 {name=l2782 sig_type=std_logic lab=WL_21_III}
C {devices/lab_pin.sym} 9680 4890 0 0 {name=l2783 sig_type=std_logic lab=PL_21_III}
C {devices/lab_pin.sym} 9680 4950 0 0 {name=l2784 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 4920 0 0 {name=Xc_21_24
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 4890 0 0 {name=l2785 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 4950 0 0 {name=l2786 sig_type=std_logic lab=WL_21_III}
C {devices/lab_pin.sym} 10080 4890 0 0 {name=l2787 sig_type=std_logic lab=PL_21_III}
C {devices/lab_pin.sym} 10080 4950 0 0 {name=l2788 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 4920 0 0 {name=Xc_21_25
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 4890 0 0 {name=l2789 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 4950 0 0 {name=l2790 sig_type=std_logic lab=WL_21_III}
C {devices/lab_pin.sym} 10480 4890 0 0 {name=l2791 sig_type=std_logic lab=PL_21_III}
C {devices/lab_pin.sym} 10480 4950 0 0 {name=l2792 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 4920 0 0 {name=Xc_21_26
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 4890 0 0 {name=l2793 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 4950 0 0 {name=l2794 sig_type=std_logic lab=WL_21_III}
C {devices/lab_pin.sym} 10880 4890 0 0 {name=l2795 sig_type=std_logic lab=PL_21_III}
C {devices/lab_pin.sym} 10880 4950 0 0 {name=l2796 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 4920 0 0 {name=Xc_21_27
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 4890 0 0 {name=l2797 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 4950 0 0 {name=l2798 sig_type=std_logic lab=WL_21_III}
C {devices/lab_pin.sym} 11280 4890 0 0 {name=l2799 sig_type=std_logic lab=PL_21_III}
C {devices/lab_pin.sym} 11280 4950 0 0 {name=l2800 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 4920 0 0 {name=Xc_21_28
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 4890 0 0 {name=l2801 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 4950 0 0 {name=l2802 sig_type=std_logic lab=WL_21_III}
C {devices/lab_pin.sym} 11680 4890 0 0 {name=l2803 sig_type=std_logic lab=PL_21_III}
C {devices/lab_pin.sym} 11680 4950 0 0 {name=l2804 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 4920 0 0 {name=Xc_21_29
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 4890 0 0 {name=l2805 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 4950 0 0 {name=l2806 sig_type=std_logic lab=WL_21_III}
C {devices/lab_pin.sym} 12080 4890 0 0 {name=l2807 sig_type=std_logic lab=PL_21_III}
C {devices/lab_pin.sym} 12080 4950 0 0 {name=l2808 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 4920 0 0 {name=Xc_21_30
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 4890 0 0 {name=l2809 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 4950 0 0 {name=l2810 sig_type=std_logic lab=WL_21_III}
C {devices/lab_pin.sym} 12480 4890 0 0 {name=l2811 sig_type=std_logic lab=PL_21_III}
C {devices/lab_pin.sym} 12480 4950 0 0 {name=l2812 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 4920 0 0 {name=Xc_21_31
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 4890 0 0 {name=l2813 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 4950 0 0 {name=l2814 sig_type=std_logic lab=WL_21_III}
C {devices/lab_pin.sym} 12880 4890 0 0 {name=l2815 sig_type=std_logic lab=PL_21_III}
C {devices/lab_pin.sym} 12880 4950 0 0 {name=l2816 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 5140 0 0 {name=Xc_22_0
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 5110 0 0 {name=l2817 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 5170 0 0 {name=l2818 sig_type=std_logic lab=WL_22_I}
C {devices/lab_pin.sym} 480 5110 0 0 {name=l2819 sig_type=std_logic lab=PL_22_I}
C {devices/lab_pin.sym} 480 5170 0 0 {name=l2820 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 5140 0 0 {name=Xc_22_1
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 5110 0 0 {name=l2821 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 5170 0 0 {name=l2822 sig_type=std_logic lab=WL_22_I}
C {devices/lab_pin.sym} 880 5110 0 0 {name=l2823 sig_type=std_logic lab=PL_22_I}
C {devices/lab_pin.sym} 880 5170 0 0 {name=l2824 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 5140 0 0 {name=Xc_22_2
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 5110 0 0 {name=l2825 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 5170 0 0 {name=l2826 sig_type=std_logic lab=WL_22_I}
C {devices/lab_pin.sym} 1280 5110 0 0 {name=l2827 sig_type=std_logic lab=PL_22_I}
C {devices/lab_pin.sym} 1280 5170 0 0 {name=l2828 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 5140 0 0 {name=Xc_22_3
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 5110 0 0 {name=l2829 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 5170 0 0 {name=l2830 sig_type=std_logic lab=WL_22_I}
C {devices/lab_pin.sym} 1680 5110 0 0 {name=l2831 sig_type=std_logic lab=PL_22_I}
C {devices/lab_pin.sym} 1680 5170 0 0 {name=l2832 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 5140 0 0 {name=Xc_22_4
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 5110 0 0 {name=l2833 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 5170 0 0 {name=l2834 sig_type=std_logic lab=WL_22_I}
C {devices/lab_pin.sym} 2080 5110 0 0 {name=l2835 sig_type=std_logic lab=PL_22_I}
C {devices/lab_pin.sym} 2080 5170 0 0 {name=l2836 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 5140 0 0 {name=Xc_22_5
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 5110 0 0 {name=l2837 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 5170 0 0 {name=l2838 sig_type=std_logic lab=WL_22_I}
C {devices/lab_pin.sym} 2480 5110 0 0 {name=l2839 sig_type=std_logic lab=PL_22_I}
C {devices/lab_pin.sym} 2480 5170 0 0 {name=l2840 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 5140 0 0 {name=Xc_22_6
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 5110 0 0 {name=l2841 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 5170 0 0 {name=l2842 sig_type=std_logic lab=WL_22_I}
C {devices/lab_pin.sym} 2880 5110 0 0 {name=l2843 sig_type=std_logic lab=PL_22_I}
C {devices/lab_pin.sym} 2880 5170 0 0 {name=l2844 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 5140 0 0 {name=Xc_22_7
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 5110 0 0 {name=l2845 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 5170 0 0 {name=l2846 sig_type=std_logic lab=WL_22_I}
C {devices/lab_pin.sym} 3280 5110 0 0 {name=l2847 sig_type=std_logic lab=PL_22_I}
C {devices/lab_pin.sym} 3280 5170 0 0 {name=l2848 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 5140 0 0 {name=Xc_22_8
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 5110 0 0 {name=l2849 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 5170 0 0 {name=l2850 sig_type=std_logic lab=WL_22_I}
C {devices/lab_pin.sym} 3680 5110 0 0 {name=l2851 sig_type=std_logic lab=PL_22_I}
C {devices/lab_pin.sym} 3680 5170 0 0 {name=l2852 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 5140 0 0 {name=Xc_22_9
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 5110 0 0 {name=l2853 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 5170 0 0 {name=l2854 sig_type=std_logic lab=WL_22_I}
C {devices/lab_pin.sym} 4080 5110 0 0 {name=l2855 sig_type=std_logic lab=PL_22_I}
C {devices/lab_pin.sym} 4080 5170 0 0 {name=l2856 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 5140 0 0 {name=Xc_22_10
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 5110 0 0 {name=l2857 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 5170 0 0 {name=l2858 sig_type=std_logic lab=WL_22_I}
C {devices/lab_pin.sym} 4480 5110 0 0 {name=l2859 sig_type=std_logic lab=PL_22_I}
C {devices/lab_pin.sym} 4480 5170 0 0 {name=l2860 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 5140 0 0 {name=Xc_22_11
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 5110 0 0 {name=l2861 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 5170 0 0 {name=l2862 sig_type=std_logic lab=WL_22_II}
C {devices/lab_pin.sym} 4880 5110 0 0 {name=l2863 sig_type=std_logic lab=PL_22_II}
C {devices/lab_pin.sym} 4880 5170 0 0 {name=l2864 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 5140 0 0 {name=Xc_22_12
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 5110 0 0 {name=l2865 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 5170 0 0 {name=l2866 sig_type=std_logic lab=WL_22_II}
C {devices/lab_pin.sym} 5280 5110 0 0 {name=l2867 sig_type=std_logic lab=PL_22_II}
C {devices/lab_pin.sym} 5280 5170 0 0 {name=l2868 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 5140 0 0 {name=Xc_22_13
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 5110 0 0 {name=l2869 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 5170 0 0 {name=l2870 sig_type=std_logic lab=WL_22_II}
C {devices/lab_pin.sym} 5680 5110 0 0 {name=l2871 sig_type=std_logic lab=PL_22_II}
C {devices/lab_pin.sym} 5680 5170 0 0 {name=l2872 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 5140 0 0 {name=Xc_22_14
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 5110 0 0 {name=l2873 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 5170 0 0 {name=l2874 sig_type=std_logic lab=WL_22_II}
C {devices/lab_pin.sym} 6080 5110 0 0 {name=l2875 sig_type=std_logic lab=PL_22_II}
C {devices/lab_pin.sym} 6080 5170 0 0 {name=l2876 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 5140 0 0 {name=Xc_22_15
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 5110 0 0 {name=l2877 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 5170 0 0 {name=l2878 sig_type=std_logic lab=WL_22_II}
C {devices/lab_pin.sym} 6480 5110 0 0 {name=l2879 sig_type=std_logic lab=PL_22_II}
C {devices/lab_pin.sym} 6480 5170 0 0 {name=l2880 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 5140 0 0 {name=Xc_22_16
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 5110 0 0 {name=l2881 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 5170 0 0 {name=l2882 sig_type=std_logic lab=WL_22_II}
C {devices/lab_pin.sym} 6880 5110 0 0 {name=l2883 sig_type=std_logic lab=PL_22_II}
C {devices/lab_pin.sym} 6880 5170 0 0 {name=l2884 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 5140 0 0 {name=Xc_22_17
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 5110 0 0 {name=l2885 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 5170 0 0 {name=l2886 sig_type=std_logic lab=WL_22_II}
C {devices/lab_pin.sym} 7280 5110 0 0 {name=l2887 sig_type=std_logic lab=PL_22_II}
C {devices/lab_pin.sym} 7280 5170 0 0 {name=l2888 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 5140 0 0 {name=Xc_22_18
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 5110 0 0 {name=l2889 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 5170 0 0 {name=l2890 sig_type=std_logic lab=WL_22_II}
C {devices/lab_pin.sym} 7680 5110 0 0 {name=l2891 sig_type=std_logic lab=PL_22_II}
C {devices/lab_pin.sym} 7680 5170 0 0 {name=l2892 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 5140 0 0 {name=Xc_22_19
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 5110 0 0 {name=l2893 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 5170 0 0 {name=l2894 sig_type=std_logic lab=WL_22_II}
C {devices/lab_pin.sym} 8080 5110 0 0 {name=l2895 sig_type=std_logic lab=PL_22_II}
C {devices/lab_pin.sym} 8080 5170 0 0 {name=l2896 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 5140 0 0 {name=Xc_22_20
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 5110 0 0 {name=l2897 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 5170 0 0 {name=l2898 sig_type=std_logic lab=WL_22_II}
C {devices/lab_pin.sym} 8480 5110 0 0 {name=l2899 sig_type=std_logic lab=PL_22_II}
C {devices/lab_pin.sym} 8480 5170 0 0 {name=l2900 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 5140 0 0 {name=Xc_22_21
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 5110 0 0 {name=l2901 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 5170 0 0 {name=l2902 sig_type=std_logic lab=WL_22_II}
C {devices/lab_pin.sym} 8880 5110 0 0 {name=l2903 sig_type=std_logic lab=PL_22_II}
C {devices/lab_pin.sym} 8880 5170 0 0 {name=l2904 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 5140 0 0 {name=Xc_22_22
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 5110 0 0 {name=l2905 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 5170 0 0 {name=l2906 sig_type=std_logic lab=WL_22_III}
C {devices/lab_pin.sym} 9280 5110 0 0 {name=l2907 sig_type=std_logic lab=PL_22_III}
C {devices/lab_pin.sym} 9280 5170 0 0 {name=l2908 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 5140 0 0 {name=Xc_22_23
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 5110 0 0 {name=l2909 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 5170 0 0 {name=l2910 sig_type=std_logic lab=WL_22_III}
C {devices/lab_pin.sym} 9680 5110 0 0 {name=l2911 sig_type=std_logic lab=PL_22_III}
C {devices/lab_pin.sym} 9680 5170 0 0 {name=l2912 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 5140 0 0 {name=Xc_22_24
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 5110 0 0 {name=l2913 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 5170 0 0 {name=l2914 sig_type=std_logic lab=WL_22_III}
C {devices/lab_pin.sym} 10080 5110 0 0 {name=l2915 sig_type=std_logic lab=PL_22_III}
C {devices/lab_pin.sym} 10080 5170 0 0 {name=l2916 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 5140 0 0 {name=Xc_22_25
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 5110 0 0 {name=l2917 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 5170 0 0 {name=l2918 sig_type=std_logic lab=WL_22_III}
C {devices/lab_pin.sym} 10480 5110 0 0 {name=l2919 sig_type=std_logic lab=PL_22_III}
C {devices/lab_pin.sym} 10480 5170 0 0 {name=l2920 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 5140 0 0 {name=Xc_22_26
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 5110 0 0 {name=l2921 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 5170 0 0 {name=l2922 sig_type=std_logic lab=WL_22_III}
C {devices/lab_pin.sym} 10880 5110 0 0 {name=l2923 sig_type=std_logic lab=PL_22_III}
C {devices/lab_pin.sym} 10880 5170 0 0 {name=l2924 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 5140 0 0 {name=Xc_22_27
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 5110 0 0 {name=l2925 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 5170 0 0 {name=l2926 sig_type=std_logic lab=WL_22_III}
C {devices/lab_pin.sym} 11280 5110 0 0 {name=l2927 sig_type=std_logic lab=PL_22_III}
C {devices/lab_pin.sym} 11280 5170 0 0 {name=l2928 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 5140 0 0 {name=Xc_22_28
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 5110 0 0 {name=l2929 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 5170 0 0 {name=l2930 sig_type=std_logic lab=WL_22_III}
C {devices/lab_pin.sym} 11680 5110 0 0 {name=l2931 sig_type=std_logic lab=PL_22_III}
C {devices/lab_pin.sym} 11680 5170 0 0 {name=l2932 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 5140 0 0 {name=Xc_22_29
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 5110 0 0 {name=l2933 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 5170 0 0 {name=l2934 sig_type=std_logic lab=WL_22_III}
C {devices/lab_pin.sym} 12080 5110 0 0 {name=l2935 sig_type=std_logic lab=PL_22_III}
C {devices/lab_pin.sym} 12080 5170 0 0 {name=l2936 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 5140 0 0 {name=Xc_22_30
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 5110 0 0 {name=l2937 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 5170 0 0 {name=l2938 sig_type=std_logic lab=WL_22_III}
C {devices/lab_pin.sym} 12480 5110 0 0 {name=l2939 sig_type=std_logic lab=PL_22_III}
C {devices/lab_pin.sym} 12480 5170 0 0 {name=l2940 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 5140 0 0 {name=Xc_22_31
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 5110 0 0 {name=l2941 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 5170 0 0 {name=l2942 sig_type=std_logic lab=WL_22_III}
C {devices/lab_pin.sym} 12880 5110 0 0 {name=l2943 sig_type=std_logic lab=PL_22_III}
C {devices/lab_pin.sym} 12880 5170 0 0 {name=l2944 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 5360 0 0 {name=Xc_23_0
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 5330 0 0 {name=l2945 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 5390 0 0 {name=l2946 sig_type=std_logic lab=WL_23_I}
C {devices/lab_pin.sym} 480 5330 0 0 {name=l2947 sig_type=std_logic lab=PL_23_I}
C {devices/lab_pin.sym} 480 5390 0 0 {name=l2948 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 5360 0 0 {name=Xc_23_1
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 5330 0 0 {name=l2949 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 5390 0 0 {name=l2950 sig_type=std_logic lab=WL_23_I}
C {devices/lab_pin.sym} 880 5330 0 0 {name=l2951 sig_type=std_logic lab=PL_23_I}
C {devices/lab_pin.sym} 880 5390 0 0 {name=l2952 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 5360 0 0 {name=Xc_23_2
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 5330 0 0 {name=l2953 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 5390 0 0 {name=l2954 sig_type=std_logic lab=WL_23_I}
C {devices/lab_pin.sym} 1280 5330 0 0 {name=l2955 sig_type=std_logic lab=PL_23_I}
C {devices/lab_pin.sym} 1280 5390 0 0 {name=l2956 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 5360 0 0 {name=Xc_23_3
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 5330 0 0 {name=l2957 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 5390 0 0 {name=l2958 sig_type=std_logic lab=WL_23_I}
C {devices/lab_pin.sym} 1680 5330 0 0 {name=l2959 sig_type=std_logic lab=PL_23_I}
C {devices/lab_pin.sym} 1680 5390 0 0 {name=l2960 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 5360 0 0 {name=Xc_23_4
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 5330 0 0 {name=l2961 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 5390 0 0 {name=l2962 sig_type=std_logic lab=WL_23_I}
C {devices/lab_pin.sym} 2080 5330 0 0 {name=l2963 sig_type=std_logic lab=PL_23_I}
C {devices/lab_pin.sym} 2080 5390 0 0 {name=l2964 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 5360 0 0 {name=Xc_23_5
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 5330 0 0 {name=l2965 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 5390 0 0 {name=l2966 sig_type=std_logic lab=WL_23_I}
C {devices/lab_pin.sym} 2480 5330 0 0 {name=l2967 sig_type=std_logic lab=PL_23_I}
C {devices/lab_pin.sym} 2480 5390 0 0 {name=l2968 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 5360 0 0 {name=Xc_23_6
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 5330 0 0 {name=l2969 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 5390 0 0 {name=l2970 sig_type=std_logic lab=WL_23_I}
C {devices/lab_pin.sym} 2880 5330 0 0 {name=l2971 sig_type=std_logic lab=PL_23_I}
C {devices/lab_pin.sym} 2880 5390 0 0 {name=l2972 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 5360 0 0 {name=Xc_23_7
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 5330 0 0 {name=l2973 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 5390 0 0 {name=l2974 sig_type=std_logic lab=WL_23_I}
C {devices/lab_pin.sym} 3280 5330 0 0 {name=l2975 sig_type=std_logic lab=PL_23_I}
C {devices/lab_pin.sym} 3280 5390 0 0 {name=l2976 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 5360 0 0 {name=Xc_23_8
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 5330 0 0 {name=l2977 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 5390 0 0 {name=l2978 sig_type=std_logic lab=WL_23_I}
C {devices/lab_pin.sym} 3680 5330 0 0 {name=l2979 sig_type=std_logic lab=PL_23_I}
C {devices/lab_pin.sym} 3680 5390 0 0 {name=l2980 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 5360 0 0 {name=Xc_23_9
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 5330 0 0 {name=l2981 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 5390 0 0 {name=l2982 sig_type=std_logic lab=WL_23_I}
C {devices/lab_pin.sym} 4080 5330 0 0 {name=l2983 sig_type=std_logic lab=PL_23_I}
C {devices/lab_pin.sym} 4080 5390 0 0 {name=l2984 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 5360 0 0 {name=Xc_23_10
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 5330 0 0 {name=l2985 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 5390 0 0 {name=l2986 sig_type=std_logic lab=WL_23_I}
C {devices/lab_pin.sym} 4480 5330 0 0 {name=l2987 sig_type=std_logic lab=PL_23_I}
C {devices/lab_pin.sym} 4480 5390 0 0 {name=l2988 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 5360 0 0 {name=Xc_23_11
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 5330 0 0 {name=l2989 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 5390 0 0 {name=l2990 sig_type=std_logic lab=WL_23_II}
C {devices/lab_pin.sym} 4880 5330 0 0 {name=l2991 sig_type=std_logic lab=PL_23_II}
C {devices/lab_pin.sym} 4880 5390 0 0 {name=l2992 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 5360 0 0 {name=Xc_23_12
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 5330 0 0 {name=l2993 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 5390 0 0 {name=l2994 sig_type=std_logic lab=WL_23_II}
C {devices/lab_pin.sym} 5280 5330 0 0 {name=l2995 sig_type=std_logic lab=PL_23_II}
C {devices/lab_pin.sym} 5280 5390 0 0 {name=l2996 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 5360 0 0 {name=Xc_23_13
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 5330 0 0 {name=l2997 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 5390 0 0 {name=l2998 sig_type=std_logic lab=WL_23_II}
C {devices/lab_pin.sym} 5680 5330 0 0 {name=l2999 sig_type=std_logic lab=PL_23_II}
C {devices/lab_pin.sym} 5680 5390 0 0 {name=l3000 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 5360 0 0 {name=Xc_23_14
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 5330 0 0 {name=l3001 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 5390 0 0 {name=l3002 sig_type=std_logic lab=WL_23_II}
C {devices/lab_pin.sym} 6080 5330 0 0 {name=l3003 sig_type=std_logic lab=PL_23_II}
C {devices/lab_pin.sym} 6080 5390 0 0 {name=l3004 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 5360 0 0 {name=Xc_23_15
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 5330 0 0 {name=l3005 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 5390 0 0 {name=l3006 sig_type=std_logic lab=WL_23_II}
C {devices/lab_pin.sym} 6480 5330 0 0 {name=l3007 sig_type=std_logic lab=PL_23_II}
C {devices/lab_pin.sym} 6480 5390 0 0 {name=l3008 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 5360 0 0 {name=Xc_23_16
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 5330 0 0 {name=l3009 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 5390 0 0 {name=l3010 sig_type=std_logic lab=WL_23_II}
C {devices/lab_pin.sym} 6880 5330 0 0 {name=l3011 sig_type=std_logic lab=PL_23_II}
C {devices/lab_pin.sym} 6880 5390 0 0 {name=l3012 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 5360 0 0 {name=Xc_23_17
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 5330 0 0 {name=l3013 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 5390 0 0 {name=l3014 sig_type=std_logic lab=WL_23_II}
C {devices/lab_pin.sym} 7280 5330 0 0 {name=l3015 sig_type=std_logic lab=PL_23_II}
C {devices/lab_pin.sym} 7280 5390 0 0 {name=l3016 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 5360 0 0 {name=Xc_23_18
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 5330 0 0 {name=l3017 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 5390 0 0 {name=l3018 sig_type=std_logic lab=WL_23_II}
C {devices/lab_pin.sym} 7680 5330 0 0 {name=l3019 sig_type=std_logic lab=PL_23_II}
C {devices/lab_pin.sym} 7680 5390 0 0 {name=l3020 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 5360 0 0 {name=Xc_23_19
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 5330 0 0 {name=l3021 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 5390 0 0 {name=l3022 sig_type=std_logic lab=WL_23_II}
C {devices/lab_pin.sym} 8080 5330 0 0 {name=l3023 sig_type=std_logic lab=PL_23_II}
C {devices/lab_pin.sym} 8080 5390 0 0 {name=l3024 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 5360 0 0 {name=Xc_23_20
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 5330 0 0 {name=l3025 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 5390 0 0 {name=l3026 sig_type=std_logic lab=WL_23_II}
C {devices/lab_pin.sym} 8480 5330 0 0 {name=l3027 sig_type=std_logic lab=PL_23_II}
C {devices/lab_pin.sym} 8480 5390 0 0 {name=l3028 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 5360 0 0 {name=Xc_23_21
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 5330 0 0 {name=l3029 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 5390 0 0 {name=l3030 sig_type=std_logic lab=WL_23_II}
C {devices/lab_pin.sym} 8880 5330 0 0 {name=l3031 sig_type=std_logic lab=PL_23_II}
C {devices/lab_pin.sym} 8880 5390 0 0 {name=l3032 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 5360 0 0 {name=Xc_23_22
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 5330 0 0 {name=l3033 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 5390 0 0 {name=l3034 sig_type=std_logic lab=WL_23_III}
C {devices/lab_pin.sym} 9280 5330 0 0 {name=l3035 sig_type=std_logic lab=PL_23_III}
C {devices/lab_pin.sym} 9280 5390 0 0 {name=l3036 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 5360 0 0 {name=Xc_23_23
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 5330 0 0 {name=l3037 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 5390 0 0 {name=l3038 sig_type=std_logic lab=WL_23_III}
C {devices/lab_pin.sym} 9680 5330 0 0 {name=l3039 sig_type=std_logic lab=PL_23_III}
C {devices/lab_pin.sym} 9680 5390 0 0 {name=l3040 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 5360 0 0 {name=Xc_23_24
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 5330 0 0 {name=l3041 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 5390 0 0 {name=l3042 sig_type=std_logic lab=WL_23_III}
C {devices/lab_pin.sym} 10080 5330 0 0 {name=l3043 sig_type=std_logic lab=PL_23_III}
C {devices/lab_pin.sym} 10080 5390 0 0 {name=l3044 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 5360 0 0 {name=Xc_23_25
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 5330 0 0 {name=l3045 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 5390 0 0 {name=l3046 sig_type=std_logic lab=WL_23_III}
C {devices/lab_pin.sym} 10480 5330 0 0 {name=l3047 sig_type=std_logic lab=PL_23_III}
C {devices/lab_pin.sym} 10480 5390 0 0 {name=l3048 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 5360 0 0 {name=Xc_23_26
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 5330 0 0 {name=l3049 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 5390 0 0 {name=l3050 sig_type=std_logic lab=WL_23_III}
C {devices/lab_pin.sym} 10880 5330 0 0 {name=l3051 sig_type=std_logic lab=PL_23_III}
C {devices/lab_pin.sym} 10880 5390 0 0 {name=l3052 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 5360 0 0 {name=Xc_23_27
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 5330 0 0 {name=l3053 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 5390 0 0 {name=l3054 sig_type=std_logic lab=WL_23_III}
C {devices/lab_pin.sym} 11280 5330 0 0 {name=l3055 sig_type=std_logic lab=PL_23_III}
C {devices/lab_pin.sym} 11280 5390 0 0 {name=l3056 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 5360 0 0 {name=Xc_23_28
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 5330 0 0 {name=l3057 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 5390 0 0 {name=l3058 sig_type=std_logic lab=WL_23_III}
C {devices/lab_pin.sym} 11680 5330 0 0 {name=l3059 sig_type=std_logic lab=PL_23_III}
C {devices/lab_pin.sym} 11680 5390 0 0 {name=l3060 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 5360 0 0 {name=Xc_23_29
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 5330 0 0 {name=l3061 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 5390 0 0 {name=l3062 sig_type=std_logic lab=WL_23_III}
C {devices/lab_pin.sym} 12080 5330 0 0 {name=l3063 sig_type=std_logic lab=PL_23_III}
C {devices/lab_pin.sym} 12080 5390 0 0 {name=l3064 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 5360 0 0 {name=Xc_23_30
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 5330 0 0 {name=l3065 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 5390 0 0 {name=l3066 sig_type=std_logic lab=WL_23_III}
C {devices/lab_pin.sym} 12480 5330 0 0 {name=l3067 sig_type=std_logic lab=PL_23_III}
C {devices/lab_pin.sym} 12480 5390 0 0 {name=l3068 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 5360 0 0 {name=Xc_23_31
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 5330 0 0 {name=l3069 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 5390 0 0 {name=l3070 sig_type=std_logic lab=WL_23_III}
C {devices/lab_pin.sym} 12880 5330 0 0 {name=l3071 sig_type=std_logic lab=PL_23_III}
C {devices/lab_pin.sym} 12880 5390 0 0 {name=l3072 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 5580 0 0 {name=Xc_24_0
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 5550 0 0 {name=l3073 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 5610 0 0 {name=l3074 sig_type=std_logic lab=WL_24_I}
C {devices/lab_pin.sym} 480 5550 0 0 {name=l3075 sig_type=std_logic lab=PL_24_I}
C {devices/lab_pin.sym} 480 5610 0 0 {name=l3076 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 5580 0 0 {name=Xc_24_1
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 5550 0 0 {name=l3077 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 5610 0 0 {name=l3078 sig_type=std_logic lab=WL_24_I}
C {devices/lab_pin.sym} 880 5550 0 0 {name=l3079 sig_type=std_logic lab=PL_24_I}
C {devices/lab_pin.sym} 880 5610 0 0 {name=l3080 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 5580 0 0 {name=Xc_24_2
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 5550 0 0 {name=l3081 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 5610 0 0 {name=l3082 sig_type=std_logic lab=WL_24_I}
C {devices/lab_pin.sym} 1280 5550 0 0 {name=l3083 sig_type=std_logic lab=PL_24_I}
C {devices/lab_pin.sym} 1280 5610 0 0 {name=l3084 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 5580 0 0 {name=Xc_24_3
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 5550 0 0 {name=l3085 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 5610 0 0 {name=l3086 sig_type=std_logic lab=WL_24_I}
C {devices/lab_pin.sym} 1680 5550 0 0 {name=l3087 sig_type=std_logic lab=PL_24_I}
C {devices/lab_pin.sym} 1680 5610 0 0 {name=l3088 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 5580 0 0 {name=Xc_24_4
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 5550 0 0 {name=l3089 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 5610 0 0 {name=l3090 sig_type=std_logic lab=WL_24_I}
C {devices/lab_pin.sym} 2080 5550 0 0 {name=l3091 sig_type=std_logic lab=PL_24_I}
C {devices/lab_pin.sym} 2080 5610 0 0 {name=l3092 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 5580 0 0 {name=Xc_24_5
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 5550 0 0 {name=l3093 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 5610 0 0 {name=l3094 sig_type=std_logic lab=WL_24_I}
C {devices/lab_pin.sym} 2480 5550 0 0 {name=l3095 sig_type=std_logic lab=PL_24_I}
C {devices/lab_pin.sym} 2480 5610 0 0 {name=l3096 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 5580 0 0 {name=Xc_24_6
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 5550 0 0 {name=l3097 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 5610 0 0 {name=l3098 sig_type=std_logic lab=WL_24_I}
C {devices/lab_pin.sym} 2880 5550 0 0 {name=l3099 sig_type=std_logic lab=PL_24_I}
C {devices/lab_pin.sym} 2880 5610 0 0 {name=l3100 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 5580 0 0 {name=Xc_24_7
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 5550 0 0 {name=l3101 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 5610 0 0 {name=l3102 sig_type=std_logic lab=WL_24_I}
C {devices/lab_pin.sym} 3280 5550 0 0 {name=l3103 sig_type=std_logic lab=PL_24_I}
C {devices/lab_pin.sym} 3280 5610 0 0 {name=l3104 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 5580 0 0 {name=Xc_24_8
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 5550 0 0 {name=l3105 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 5610 0 0 {name=l3106 sig_type=std_logic lab=WL_24_I}
C {devices/lab_pin.sym} 3680 5550 0 0 {name=l3107 sig_type=std_logic lab=PL_24_I}
C {devices/lab_pin.sym} 3680 5610 0 0 {name=l3108 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 5580 0 0 {name=Xc_24_9
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 5550 0 0 {name=l3109 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 5610 0 0 {name=l3110 sig_type=std_logic lab=WL_24_I}
C {devices/lab_pin.sym} 4080 5550 0 0 {name=l3111 sig_type=std_logic lab=PL_24_I}
C {devices/lab_pin.sym} 4080 5610 0 0 {name=l3112 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 5580 0 0 {name=Xc_24_10
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 5550 0 0 {name=l3113 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 5610 0 0 {name=l3114 sig_type=std_logic lab=WL_24_I}
C {devices/lab_pin.sym} 4480 5550 0 0 {name=l3115 sig_type=std_logic lab=PL_24_I}
C {devices/lab_pin.sym} 4480 5610 0 0 {name=l3116 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 5580 0 0 {name=Xc_24_11
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 5550 0 0 {name=l3117 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 5610 0 0 {name=l3118 sig_type=std_logic lab=WL_24_II}
C {devices/lab_pin.sym} 4880 5550 0 0 {name=l3119 sig_type=std_logic lab=PL_24_II}
C {devices/lab_pin.sym} 4880 5610 0 0 {name=l3120 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 5580 0 0 {name=Xc_24_12
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 5550 0 0 {name=l3121 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 5610 0 0 {name=l3122 sig_type=std_logic lab=WL_24_II}
C {devices/lab_pin.sym} 5280 5550 0 0 {name=l3123 sig_type=std_logic lab=PL_24_II}
C {devices/lab_pin.sym} 5280 5610 0 0 {name=l3124 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 5580 0 0 {name=Xc_24_13
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 5550 0 0 {name=l3125 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 5610 0 0 {name=l3126 sig_type=std_logic lab=WL_24_II}
C {devices/lab_pin.sym} 5680 5550 0 0 {name=l3127 sig_type=std_logic lab=PL_24_II}
C {devices/lab_pin.sym} 5680 5610 0 0 {name=l3128 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 5580 0 0 {name=Xc_24_14
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 5550 0 0 {name=l3129 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 5610 0 0 {name=l3130 sig_type=std_logic lab=WL_24_II}
C {devices/lab_pin.sym} 6080 5550 0 0 {name=l3131 sig_type=std_logic lab=PL_24_II}
C {devices/lab_pin.sym} 6080 5610 0 0 {name=l3132 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 5580 0 0 {name=Xc_24_15
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 5550 0 0 {name=l3133 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 5610 0 0 {name=l3134 sig_type=std_logic lab=WL_24_II}
C {devices/lab_pin.sym} 6480 5550 0 0 {name=l3135 sig_type=std_logic lab=PL_24_II}
C {devices/lab_pin.sym} 6480 5610 0 0 {name=l3136 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 5580 0 0 {name=Xc_24_16
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 5550 0 0 {name=l3137 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 5610 0 0 {name=l3138 sig_type=std_logic lab=WL_24_II}
C {devices/lab_pin.sym} 6880 5550 0 0 {name=l3139 sig_type=std_logic lab=PL_24_II}
C {devices/lab_pin.sym} 6880 5610 0 0 {name=l3140 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 5580 0 0 {name=Xc_24_17
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 5550 0 0 {name=l3141 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 5610 0 0 {name=l3142 sig_type=std_logic lab=WL_24_II}
C {devices/lab_pin.sym} 7280 5550 0 0 {name=l3143 sig_type=std_logic lab=PL_24_II}
C {devices/lab_pin.sym} 7280 5610 0 0 {name=l3144 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 5580 0 0 {name=Xc_24_18
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 5550 0 0 {name=l3145 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 5610 0 0 {name=l3146 sig_type=std_logic lab=WL_24_II}
C {devices/lab_pin.sym} 7680 5550 0 0 {name=l3147 sig_type=std_logic lab=PL_24_II}
C {devices/lab_pin.sym} 7680 5610 0 0 {name=l3148 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 5580 0 0 {name=Xc_24_19
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 5550 0 0 {name=l3149 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 5610 0 0 {name=l3150 sig_type=std_logic lab=WL_24_II}
C {devices/lab_pin.sym} 8080 5550 0 0 {name=l3151 sig_type=std_logic lab=PL_24_II}
C {devices/lab_pin.sym} 8080 5610 0 0 {name=l3152 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 5580 0 0 {name=Xc_24_20
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 5550 0 0 {name=l3153 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 5610 0 0 {name=l3154 sig_type=std_logic lab=WL_24_II}
C {devices/lab_pin.sym} 8480 5550 0 0 {name=l3155 sig_type=std_logic lab=PL_24_II}
C {devices/lab_pin.sym} 8480 5610 0 0 {name=l3156 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 5580 0 0 {name=Xc_24_21
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 5550 0 0 {name=l3157 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 5610 0 0 {name=l3158 sig_type=std_logic lab=WL_24_II}
C {devices/lab_pin.sym} 8880 5550 0 0 {name=l3159 sig_type=std_logic lab=PL_24_II}
C {devices/lab_pin.sym} 8880 5610 0 0 {name=l3160 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 5580 0 0 {name=Xc_24_22
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 5550 0 0 {name=l3161 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 5610 0 0 {name=l3162 sig_type=std_logic lab=WL_24_III}
C {devices/lab_pin.sym} 9280 5550 0 0 {name=l3163 sig_type=std_logic lab=PL_24_III}
C {devices/lab_pin.sym} 9280 5610 0 0 {name=l3164 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 5580 0 0 {name=Xc_24_23
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 5550 0 0 {name=l3165 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 5610 0 0 {name=l3166 sig_type=std_logic lab=WL_24_III}
C {devices/lab_pin.sym} 9680 5550 0 0 {name=l3167 sig_type=std_logic lab=PL_24_III}
C {devices/lab_pin.sym} 9680 5610 0 0 {name=l3168 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 5580 0 0 {name=Xc_24_24
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 5550 0 0 {name=l3169 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 5610 0 0 {name=l3170 sig_type=std_logic lab=WL_24_III}
C {devices/lab_pin.sym} 10080 5550 0 0 {name=l3171 sig_type=std_logic lab=PL_24_III}
C {devices/lab_pin.sym} 10080 5610 0 0 {name=l3172 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 5580 0 0 {name=Xc_24_25
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 5550 0 0 {name=l3173 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 5610 0 0 {name=l3174 sig_type=std_logic lab=WL_24_III}
C {devices/lab_pin.sym} 10480 5550 0 0 {name=l3175 sig_type=std_logic lab=PL_24_III}
C {devices/lab_pin.sym} 10480 5610 0 0 {name=l3176 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 5580 0 0 {name=Xc_24_26
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 5550 0 0 {name=l3177 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 5610 0 0 {name=l3178 sig_type=std_logic lab=WL_24_III}
C {devices/lab_pin.sym} 10880 5550 0 0 {name=l3179 sig_type=std_logic lab=PL_24_III}
C {devices/lab_pin.sym} 10880 5610 0 0 {name=l3180 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 5580 0 0 {name=Xc_24_27
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 5550 0 0 {name=l3181 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 5610 0 0 {name=l3182 sig_type=std_logic lab=WL_24_III}
C {devices/lab_pin.sym} 11280 5550 0 0 {name=l3183 sig_type=std_logic lab=PL_24_III}
C {devices/lab_pin.sym} 11280 5610 0 0 {name=l3184 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 5580 0 0 {name=Xc_24_28
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 5550 0 0 {name=l3185 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 5610 0 0 {name=l3186 sig_type=std_logic lab=WL_24_III}
C {devices/lab_pin.sym} 11680 5550 0 0 {name=l3187 sig_type=std_logic lab=PL_24_III}
C {devices/lab_pin.sym} 11680 5610 0 0 {name=l3188 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 5580 0 0 {name=Xc_24_29
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 5550 0 0 {name=l3189 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 5610 0 0 {name=l3190 sig_type=std_logic lab=WL_24_III}
C {devices/lab_pin.sym} 12080 5550 0 0 {name=l3191 sig_type=std_logic lab=PL_24_III}
C {devices/lab_pin.sym} 12080 5610 0 0 {name=l3192 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 5580 0 0 {name=Xc_24_30
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 5550 0 0 {name=l3193 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 5610 0 0 {name=l3194 sig_type=std_logic lab=WL_24_III}
C {devices/lab_pin.sym} 12480 5550 0 0 {name=l3195 sig_type=std_logic lab=PL_24_III}
C {devices/lab_pin.sym} 12480 5610 0 0 {name=l3196 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 5580 0 0 {name=Xc_24_31
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 5550 0 0 {name=l3197 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 5610 0 0 {name=l3198 sig_type=std_logic lab=WL_24_III}
C {devices/lab_pin.sym} 12880 5550 0 0 {name=l3199 sig_type=std_logic lab=PL_24_III}
C {devices/lab_pin.sym} 12880 5610 0 0 {name=l3200 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 5800 0 0 {name=Xc_25_0
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 5770 0 0 {name=l3201 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 5830 0 0 {name=l3202 sig_type=std_logic lab=WL_25_I}
C {devices/lab_pin.sym} 480 5770 0 0 {name=l3203 sig_type=std_logic lab=PL_25_I}
C {devices/lab_pin.sym} 480 5830 0 0 {name=l3204 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 5800 0 0 {name=Xc_25_1
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 5770 0 0 {name=l3205 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 5830 0 0 {name=l3206 sig_type=std_logic lab=WL_25_I}
C {devices/lab_pin.sym} 880 5770 0 0 {name=l3207 sig_type=std_logic lab=PL_25_I}
C {devices/lab_pin.sym} 880 5830 0 0 {name=l3208 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 5800 0 0 {name=Xc_25_2
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 5770 0 0 {name=l3209 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 5830 0 0 {name=l3210 sig_type=std_logic lab=WL_25_I}
C {devices/lab_pin.sym} 1280 5770 0 0 {name=l3211 sig_type=std_logic lab=PL_25_I}
C {devices/lab_pin.sym} 1280 5830 0 0 {name=l3212 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 5800 0 0 {name=Xc_25_3
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 5770 0 0 {name=l3213 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 5830 0 0 {name=l3214 sig_type=std_logic lab=WL_25_I}
C {devices/lab_pin.sym} 1680 5770 0 0 {name=l3215 sig_type=std_logic lab=PL_25_I}
C {devices/lab_pin.sym} 1680 5830 0 0 {name=l3216 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 5800 0 0 {name=Xc_25_4
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 5770 0 0 {name=l3217 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 5830 0 0 {name=l3218 sig_type=std_logic lab=WL_25_I}
C {devices/lab_pin.sym} 2080 5770 0 0 {name=l3219 sig_type=std_logic lab=PL_25_I}
C {devices/lab_pin.sym} 2080 5830 0 0 {name=l3220 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 5800 0 0 {name=Xc_25_5
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 5770 0 0 {name=l3221 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 5830 0 0 {name=l3222 sig_type=std_logic lab=WL_25_I}
C {devices/lab_pin.sym} 2480 5770 0 0 {name=l3223 sig_type=std_logic lab=PL_25_I}
C {devices/lab_pin.sym} 2480 5830 0 0 {name=l3224 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 5800 0 0 {name=Xc_25_6
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 5770 0 0 {name=l3225 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 5830 0 0 {name=l3226 sig_type=std_logic lab=WL_25_I}
C {devices/lab_pin.sym} 2880 5770 0 0 {name=l3227 sig_type=std_logic lab=PL_25_I}
C {devices/lab_pin.sym} 2880 5830 0 0 {name=l3228 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 5800 0 0 {name=Xc_25_7
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 5770 0 0 {name=l3229 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 5830 0 0 {name=l3230 sig_type=std_logic lab=WL_25_I}
C {devices/lab_pin.sym} 3280 5770 0 0 {name=l3231 sig_type=std_logic lab=PL_25_I}
C {devices/lab_pin.sym} 3280 5830 0 0 {name=l3232 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 5800 0 0 {name=Xc_25_8
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 5770 0 0 {name=l3233 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 5830 0 0 {name=l3234 sig_type=std_logic lab=WL_25_I}
C {devices/lab_pin.sym} 3680 5770 0 0 {name=l3235 sig_type=std_logic lab=PL_25_I}
C {devices/lab_pin.sym} 3680 5830 0 0 {name=l3236 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 5800 0 0 {name=Xc_25_9
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 5770 0 0 {name=l3237 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 5830 0 0 {name=l3238 sig_type=std_logic lab=WL_25_I}
C {devices/lab_pin.sym} 4080 5770 0 0 {name=l3239 sig_type=std_logic lab=PL_25_I}
C {devices/lab_pin.sym} 4080 5830 0 0 {name=l3240 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 5800 0 0 {name=Xc_25_10
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 5770 0 0 {name=l3241 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 5830 0 0 {name=l3242 sig_type=std_logic lab=WL_25_I}
C {devices/lab_pin.sym} 4480 5770 0 0 {name=l3243 sig_type=std_logic lab=PL_25_I}
C {devices/lab_pin.sym} 4480 5830 0 0 {name=l3244 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 5800 0 0 {name=Xc_25_11
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 5770 0 0 {name=l3245 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 5830 0 0 {name=l3246 sig_type=std_logic lab=WL_25_II}
C {devices/lab_pin.sym} 4880 5770 0 0 {name=l3247 sig_type=std_logic lab=PL_25_II}
C {devices/lab_pin.sym} 4880 5830 0 0 {name=l3248 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 5800 0 0 {name=Xc_25_12
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 5770 0 0 {name=l3249 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 5830 0 0 {name=l3250 sig_type=std_logic lab=WL_25_II}
C {devices/lab_pin.sym} 5280 5770 0 0 {name=l3251 sig_type=std_logic lab=PL_25_II}
C {devices/lab_pin.sym} 5280 5830 0 0 {name=l3252 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 5800 0 0 {name=Xc_25_13
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 5770 0 0 {name=l3253 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 5830 0 0 {name=l3254 sig_type=std_logic lab=WL_25_II}
C {devices/lab_pin.sym} 5680 5770 0 0 {name=l3255 sig_type=std_logic lab=PL_25_II}
C {devices/lab_pin.sym} 5680 5830 0 0 {name=l3256 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 5800 0 0 {name=Xc_25_14
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 5770 0 0 {name=l3257 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 5830 0 0 {name=l3258 sig_type=std_logic lab=WL_25_II}
C {devices/lab_pin.sym} 6080 5770 0 0 {name=l3259 sig_type=std_logic lab=PL_25_II}
C {devices/lab_pin.sym} 6080 5830 0 0 {name=l3260 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 5800 0 0 {name=Xc_25_15
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 5770 0 0 {name=l3261 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 5830 0 0 {name=l3262 sig_type=std_logic lab=WL_25_II}
C {devices/lab_pin.sym} 6480 5770 0 0 {name=l3263 sig_type=std_logic lab=PL_25_II}
C {devices/lab_pin.sym} 6480 5830 0 0 {name=l3264 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 5800 0 0 {name=Xc_25_16
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 5770 0 0 {name=l3265 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 5830 0 0 {name=l3266 sig_type=std_logic lab=WL_25_II}
C {devices/lab_pin.sym} 6880 5770 0 0 {name=l3267 sig_type=std_logic lab=PL_25_II}
C {devices/lab_pin.sym} 6880 5830 0 0 {name=l3268 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 5800 0 0 {name=Xc_25_17
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 5770 0 0 {name=l3269 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 5830 0 0 {name=l3270 sig_type=std_logic lab=WL_25_II}
C {devices/lab_pin.sym} 7280 5770 0 0 {name=l3271 sig_type=std_logic lab=PL_25_II}
C {devices/lab_pin.sym} 7280 5830 0 0 {name=l3272 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 5800 0 0 {name=Xc_25_18
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 5770 0 0 {name=l3273 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 5830 0 0 {name=l3274 sig_type=std_logic lab=WL_25_II}
C {devices/lab_pin.sym} 7680 5770 0 0 {name=l3275 sig_type=std_logic lab=PL_25_II}
C {devices/lab_pin.sym} 7680 5830 0 0 {name=l3276 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 5800 0 0 {name=Xc_25_19
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 5770 0 0 {name=l3277 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 5830 0 0 {name=l3278 sig_type=std_logic lab=WL_25_II}
C {devices/lab_pin.sym} 8080 5770 0 0 {name=l3279 sig_type=std_logic lab=PL_25_II}
C {devices/lab_pin.sym} 8080 5830 0 0 {name=l3280 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 5800 0 0 {name=Xc_25_20
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 5770 0 0 {name=l3281 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 5830 0 0 {name=l3282 sig_type=std_logic lab=WL_25_II}
C {devices/lab_pin.sym} 8480 5770 0 0 {name=l3283 sig_type=std_logic lab=PL_25_II}
C {devices/lab_pin.sym} 8480 5830 0 0 {name=l3284 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 5800 0 0 {name=Xc_25_21
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 5770 0 0 {name=l3285 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 5830 0 0 {name=l3286 sig_type=std_logic lab=WL_25_II}
C {devices/lab_pin.sym} 8880 5770 0 0 {name=l3287 sig_type=std_logic lab=PL_25_II}
C {devices/lab_pin.sym} 8880 5830 0 0 {name=l3288 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 5800 0 0 {name=Xc_25_22
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 5770 0 0 {name=l3289 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 5830 0 0 {name=l3290 sig_type=std_logic lab=WL_25_III}
C {devices/lab_pin.sym} 9280 5770 0 0 {name=l3291 sig_type=std_logic lab=PL_25_III}
C {devices/lab_pin.sym} 9280 5830 0 0 {name=l3292 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 5800 0 0 {name=Xc_25_23
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 5770 0 0 {name=l3293 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 5830 0 0 {name=l3294 sig_type=std_logic lab=WL_25_III}
C {devices/lab_pin.sym} 9680 5770 0 0 {name=l3295 sig_type=std_logic lab=PL_25_III}
C {devices/lab_pin.sym} 9680 5830 0 0 {name=l3296 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 5800 0 0 {name=Xc_25_24
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 5770 0 0 {name=l3297 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 5830 0 0 {name=l3298 sig_type=std_logic lab=WL_25_III}
C {devices/lab_pin.sym} 10080 5770 0 0 {name=l3299 sig_type=std_logic lab=PL_25_III}
C {devices/lab_pin.sym} 10080 5830 0 0 {name=l3300 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 5800 0 0 {name=Xc_25_25
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 5770 0 0 {name=l3301 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 5830 0 0 {name=l3302 sig_type=std_logic lab=WL_25_III}
C {devices/lab_pin.sym} 10480 5770 0 0 {name=l3303 sig_type=std_logic lab=PL_25_III}
C {devices/lab_pin.sym} 10480 5830 0 0 {name=l3304 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 5800 0 0 {name=Xc_25_26
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 5770 0 0 {name=l3305 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 5830 0 0 {name=l3306 sig_type=std_logic lab=WL_25_III}
C {devices/lab_pin.sym} 10880 5770 0 0 {name=l3307 sig_type=std_logic lab=PL_25_III}
C {devices/lab_pin.sym} 10880 5830 0 0 {name=l3308 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 5800 0 0 {name=Xc_25_27
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 5770 0 0 {name=l3309 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 5830 0 0 {name=l3310 sig_type=std_logic lab=WL_25_III}
C {devices/lab_pin.sym} 11280 5770 0 0 {name=l3311 sig_type=std_logic lab=PL_25_III}
C {devices/lab_pin.sym} 11280 5830 0 0 {name=l3312 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 5800 0 0 {name=Xc_25_28
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 5770 0 0 {name=l3313 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 5830 0 0 {name=l3314 sig_type=std_logic lab=WL_25_III}
C {devices/lab_pin.sym} 11680 5770 0 0 {name=l3315 sig_type=std_logic lab=PL_25_III}
C {devices/lab_pin.sym} 11680 5830 0 0 {name=l3316 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 5800 0 0 {name=Xc_25_29
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 5770 0 0 {name=l3317 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 5830 0 0 {name=l3318 sig_type=std_logic lab=WL_25_III}
C {devices/lab_pin.sym} 12080 5770 0 0 {name=l3319 sig_type=std_logic lab=PL_25_III}
C {devices/lab_pin.sym} 12080 5830 0 0 {name=l3320 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 5800 0 0 {name=Xc_25_30
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 5770 0 0 {name=l3321 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 5830 0 0 {name=l3322 sig_type=std_logic lab=WL_25_III}
C {devices/lab_pin.sym} 12480 5770 0 0 {name=l3323 sig_type=std_logic lab=PL_25_III}
C {devices/lab_pin.sym} 12480 5830 0 0 {name=l3324 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 5800 0 0 {name=Xc_25_31
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 5770 0 0 {name=l3325 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 5830 0 0 {name=l3326 sig_type=std_logic lab=WL_25_III}
C {devices/lab_pin.sym} 12880 5770 0 0 {name=l3327 sig_type=std_logic lab=PL_25_III}
C {devices/lab_pin.sym} 12880 5830 0 0 {name=l3328 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 6020 0 0 {name=Xc_26_0
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 5990 0 0 {name=l3329 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 6050 0 0 {name=l3330 sig_type=std_logic lab=WL_26_I}
C {devices/lab_pin.sym} 480 5990 0 0 {name=l3331 sig_type=std_logic lab=PL_26_I}
C {devices/lab_pin.sym} 480 6050 0 0 {name=l3332 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 6020 0 0 {name=Xc_26_1
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 5990 0 0 {name=l3333 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 6050 0 0 {name=l3334 sig_type=std_logic lab=WL_26_I}
C {devices/lab_pin.sym} 880 5990 0 0 {name=l3335 sig_type=std_logic lab=PL_26_I}
C {devices/lab_pin.sym} 880 6050 0 0 {name=l3336 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 6020 0 0 {name=Xc_26_2
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 5990 0 0 {name=l3337 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 6050 0 0 {name=l3338 sig_type=std_logic lab=WL_26_I}
C {devices/lab_pin.sym} 1280 5990 0 0 {name=l3339 sig_type=std_logic lab=PL_26_I}
C {devices/lab_pin.sym} 1280 6050 0 0 {name=l3340 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 6020 0 0 {name=Xc_26_3
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 5990 0 0 {name=l3341 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 6050 0 0 {name=l3342 sig_type=std_logic lab=WL_26_I}
C {devices/lab_pin.sym} 1680 5990 0 0 {name=l3343 sig_type=std_logic lab=PL_26_I}
C {devices/lab_pin.sym} 1680 6050 0 0 {name=l3344 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 6020 0 0 {name=Xc_26_4
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 5990 0 0 {name=l3345 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 6050 0 0 {name=l3346 sig_type=std_logic lab=WL_26_I}
C {devices/lab_pin.sym} 2080 5990 0 0 {name=l3347 sig_type=std_logic lab=PL_26_I}
C {devices/lab_pin.sym} 2080 6050 0 0 {name=l3348 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 6020 0 0 {name=Xc_26_5
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 5990 0 0 {name=l3349 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 6050 0 0 {name=l3350 sig_type=std_logic lab=WL_26_I}
C {devices/lab_pin.sym} 2480 5990 0 0 {name=l3351 sig_type=std_logic lab=PL_26_I}
C {devices/lab_pin.sym} 2480 6050 0 0 {name=l3352 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 6020 0 0 {name=Xc_26_6
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 5990 0 0 {name=l3353 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 6050 0 0 {name=l3354 sig_type=std_logic lab=WL_26_I}
C {devices/lab_pin.sym} 2880 5990 0 0 {name=l3355 sig_type=std_logic lab=PL_26_I}
C {devices/lab_pin.sym} 2880 6050 0 0 {name=l3356 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 6020 0 0 {name=Xc_26_7
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 5990 0 0 {name=l3357 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 6050 0 0 {name=l3358 sig_type=std_logic lab=WL_26_I}
C {devices/lab_pin.sym} 3280 5990 0 0 {name=l3359 sig_type=std_logic lab=PL_26_I}
C {devices/lab_pin.sym} 3280 6050 0 0 {name=l3360 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 6020 0 0 {name=Xc_26_8
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 5990 0 0 {name=l3361 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 6050 0 0 {name=l3362 sig_type=std_logic lab=WL_26_I}
C {devices/lab_pin.sym} 3680 5990 0 0 {name=l3363 sig_type=std_logic lab=PL_26_I}
C {devices/lab_pin.sym} 3680 6050 0 0 {name=l3364 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 6020 0 0 {name=Xc_26_9
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 5990 0 0 {name=l3365 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 6050 0 0 {name=l3366 sig_type=std_logic lab=WL_26_I}
C {devices/lab_pin.sym} 4080 5990 0 0 {name=l3367 sig_type=std_logic lab=PL_26_I}
C {devices/lab_pin.sym} 4080 6050 0 0 {name=l3368 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 6020 0 0 {name=Xc_26_10
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 5990 0 0 {name=l3369 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 6050 0 0 {name=l3370 sig_type=std_logic lab=WL_26_I}
C {devices/lab_pin.sym} 4480 5990 0 0 {name=l3371 sig_type=std_logic lab=PL_26_I}
C {devices/lab_pin.sym} 4480 6050 0 0 {name=l3372 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 6020 0 0 {name=Xc_26_11
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 5990 0 0 {name=l3373 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 6050 0 0 {name=l3374 sig_type=std_logic lab=WL_26_II}
C {devices/lab_pin.sym} 4880 5990 0 0 {name=l3375 sig_type=std_logic lab=PL_26_II}
C {devices/lab_pin.sym} 4880 6050 0 0 {name=l3376 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 6020 0 0 {name=Xc_26_12
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 5990 0 0 {name=l3377 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 6050 0 0 {name=l3378 sig_type=std_logic lab=WL_26_II}
C {devices/lab_pin.sym} 5280 5990 0 0 {name=l3379 sig_type=std_logic lab=PL_26_II}
C {devices/lab_pin.sym} 5280 6050 0 0 {name=l3380 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 6020 0 0 {name=Xc_26_13
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 5990 0 0 {name=l3381 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 6050 0 0 {name=l3382 sig_type=std_logic lab=WL_26_II}
C {devices/lab_pin.sym} 5680 5990 0 0 {name=l3383 sig_type=std_logic lab=PL_26_II}
C {devices/lab_pin.sym} 5680 6050 0 0 {name=l3384 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 6020 0 0 {name=Xc_26_14
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 5990 0 0 {name=l3385 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 6050 0 0 {name=l3386 sig_type=std_logic lab=WL_26_II}
C {devices/lab_pin.sym} 6080 5990 0 0 {name=l3387 sig_type=std_logic lab=PL_26_II}
C {devices/lab_pin.sym} 6080 6050 0 0 {name=l3388 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 6020 0 0 {name=Xc_26_15
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 5990 0 0 {name=l3389 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 6050 0 0 {name=l3390 sig_type=std_logic lab=WL_26_II}
C {devices/lab_pin.sym} 6480 5990 0 0 {name=l3391 sig_type=std_logic lab=PL_26_II}
C {devices/lab_pin.sym} 6480 6050 0 0 {name=l3392 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 6020 0 0 {name=Xc_26_16
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 5990 0 0 {name=l3393 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 6050 0 0 {name=l3394 sig_type=std_logic lab=WL_26_II}
C {devices/lab_pin.sym} 6880 5990 0 0 {name=l3395 sig_type=std_logic lab=PL_26_II}
C {devices/lab_pin.sym} 6880 6050 0 0 {name=l3396 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 6020 0 0 {name=Xc_26_17
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 5990 0 0 {name=l3397 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 6050 0 0 {name=l3398 sig_type=std_logic lab=WL_26_II}
C {devices/lab_pin.sym} 7280 5990 0 0 {name=l3399 sig_type=std_logic lab=PL_26_II}
C {devices/lab_pin.sym} 7280 6050 0 0 {name=l3400 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 6020 0 0 {name=Xc_26_18
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 5990 0 0 {name=l3401 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 6050 0 0 {name=l3402 sig_type=std_logic lab=WL_26_II}
C {devices/lab_pin.sym} 7680 5990 0 0 {name=l3403 sig_type=std_logic lab=PL_26_II}
C {devices/lab_pin.sym} 7680 6050 0 0 {name=l3404 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 6020 0 0 {name=Xc_26_19
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 5990 0 0 {name=l3405 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 6050 0 0 {name=l3406 sig_type=std_logic lab=WL_26_II}
C {devices/lab_pin.sym} 8080 5990 0 0 {name=l3407 sig_type=std_logic lab=PL_26_II}
C {devices/lab_pin.sym} 8080 6050 0 0 {name=l3408 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 6020 0 0 {name=Xc_26_20
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 5990 0 0 {name=l3409 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 6050 0 0 {name=l3410 sig_type=std_logic lab=WL_26_II}
C {devices/lab_pin.sym} 8480 5990 0 0 {name=l3411 sig_type=std_logic lab=PL_26_II}
C {devices/lab_pin.sym} 8480 6050 0 0 {name=l3412 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 6020 0 0 {name=Xc_26_21
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 5990 0 0 {name=l3413 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 6050 0 0 {name=l3414 sig_type=std_logic lab=WL_26_II}
C {devices/lab_pin.sym} 8880 5990 0 0 {name=l3415 sig_type=std_logic lab=PL_26_II}
C {devices/lab_pin.sym} 8880 6050 0 0 {name=l3416 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 6020 0 0 {name=Xc_26_22
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 5990 0 0 {name=l3417 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 6050 0 0 {name=l3418 sig_type=std_logic lab=WL_26_III}
C {devices/lab_pin.sym} 9280 5990 0 0 {name=l3419 sig_type=std_logic lab=PL_26_III}
C {devices/lab_pin.sym} 9280 6050 0 0 {name=l3420 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 6020 0 0 {name=Xc_26_23
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 5990 0 0 {name=l3421 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 6050 0 0 {name=l3422 sig_type=std_logic lab=WL_26_III}
C {devices/lab_pin.sym} 9680 5990 0 0 {name=l3423 sig_type=std_logic lab=PL_26_III}
C {devices/lab_pin.sym} 9680 6050 0 0 {name=l3424 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 6020 0 0 {name=Xc_26_24
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 5990 0 0 {name=l3425 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 6050 0 0 {name=l3426 sig_type=std_logic lab=WL_26_III}
C {devices/lab_pin.sym} 10080 5990 0 0 {name=l3427 sig_type=std_logic lab=PL_26_III}
C {devices/lab_pin.sym} 10080 6050 0 0 {name=l3428 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 6020 0 0 {name=Xc_26_25
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 5990 0 0 {name=l3429 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 6050 0 0 {name=l3430 sig_type=std_logic lab=WL_26_III}
C {devices/lab_pin.sym} 10480 5990 0 0 {name=l3431 sig_type=std_logic lab=PL_26_III}
C {devices/lab_pin.sym} 10480 6050 0 0 {name=l3432 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 6020 0 0 {name=Xc_26_26
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 5990 0 0 {name=l3433 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 6050 0 0 {name=l3434 sig_type=std_logic lab=WL_26_III}
C {devices/lab_pin.sym} 10880 5990 0 0 {name=l3435 sig_type=std_logic lab=PL_26_III}
C {devices/lab_pin.sym} 10880 6050 0 0 {name=l3436 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 6020 0 0 {name=Xc_26_27
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 5990 0 0 {name=l3437 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 6050 0 0 {name=l3438 sig_type=std_logic lab=WL_26_III}
C {devices/lab_pin.sym} 11280 5990 0 0 {name=l3439 sig_type=std_logic lab=PL_26_III}
C {devices/lab_pin.sym} 11280 6050 0 0 {name=l3440 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 6020 0 0 {name=Xc_26_28
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 5990 0 0 {name=l3441 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 6050 0 0 {name=l3442 sig_type=std_logic lab=WL_26_III}
C {devices/lab_pin.sym} 11680 5990 0 0 {name=l3443 sig_type=std_logic lab=PL_26_III}
C {devices/lab_pin.sym} 11680 6050 0 0 {name=l3444 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 6020 0 0 {name=Xc_26_29
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 5990 0 0 {name=l3445 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 6050 0 0 {name=l3446 sig_type=std_logic lab=WL_26_III}
C {devices/lab_pin.sym} 12080 5990 0 0 {name=l3447 sig_type=std_logic lab=PL_26_III}
C {devices/lab_pin.sym} 12080 6050 0 0 {name=l3448 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 6020 0 0 {name=Xc_26_30
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 5990 0 0 {name=l3449 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 6050 0 0 {name=l3450 sig_type=std_logic lab=WL_26_III}
C {devices/lab_pin.sym} 12480 5990 0 0 {name=l3451 sig_type=std_logic lab=PL_26_III}
C {devices/lab_pin.sym} 12480 6050 0 0 {name=l3452 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 6020 0 0 {name=Xc_26_31
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 5990 0 0 {name=l3453 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 6050 0 0 {name=l3454 sig_type=std_logic lab=WL_26_III}
C {devices/lab_pin.sym} 12880 5990 0 0 {name=l3455 sig_type=std_logic lab=PL_26_III}
C {devices/lab_pin.sym} 12880 6050 0 0 {name=l3456 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 6240 0 0 {name=Xc_27_0
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 6210 0 0 {name=l3457 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 6270 0 0 {name=l3458 sig_type=std_logic lab=WL_27_I}
C {devices/lab_pin.sym} 480 6210 0 0 {name=l3459 sig_type=std_logic lab=PL_27_I}
C {devices/lab_pin.sym} 480 6270 0 0 {name=l3460 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 6240 0 0 {name=Xc_27_1
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 6210 0 0 {name=l3461 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 6270 0 0 {name=l3462 sig_type=std_logic lab=WL_27_I}
C {devices/lab_pin.sym} 880 6210 0 0 {name=l3463 sig_type=std_logic lab=PL_27_I}
C {devices/lab_pin.sym} 880 6270 0 0 {name=l3464 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 6240 0 0 {name=Xc_27_2
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 6210 0 0 {name=l3465 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 6270 0 0 {name=l3466 sig_type=std_logic lab=WL_27_I}
C {devices/lab_pin.sym} 1280 6210 0 0 {name=l3467 sig_type=std_logic lab=PL_27_I}
C {devices/lab_pin.sym} 1280 6270 0 0 {name=l3468 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 6240 0 0 {name=Xc_27_3
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 6210 0 0 {name=l3469 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 6270 0 0 {name=l3470 sig_type=std_logic lab=WL_27_I}
C {devices/lab_pin.sym} 1680 6210 0 0 {name=l3471 sig_type=std_logic lab=PL_27_I}
C {devices/lab_pin.sym} 1680 6270 0 0 {name=l3472 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 6240 0 0 {name=Xc_27_4
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 6210 0 0 {name=l3473 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 6270 0 0 {name=l3474 sig_type=std_logic lab=WL_27_I}
C {devices/lab_pin.sym} 2080 6210 0 0 {name=l3475 sig_type=std_logic lab=PL_27_I}
C {devices/lab_pin.sym} 2080 6270 0 0 {name=l3476 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 6240 0 0 {name=Xc_27_5
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 6210 0 0 {name=l3477 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 6270 0 0 {name=l3478 sig_type=std_logic lab=WL_27_I}
C {devices/lab_pin.sym} 2480 6210 0 0 {name=l3479 sig_type=std_logic lab=PL_27_I}
C {devices/lab_pin.sym} 2480 6270 0 0 {name=l3480 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 6240 0 0 {name=Xc_27_6
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 6210 0 0 {name=l3481 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 6270 0 0 {name=l3482 sig_type=std_logic lab=WL_27_I}
C {devices/lab_pin.sym} 2880 6210 0 0 {name=l3483 sig_type=std_logic lab=PL_27_I}
C {devices/lab_pin.sym} 2880 6270 0 0 {name=l3484 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 6240 0 0 {name=Xc_27_7
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 6210 0 0 {name=l3485 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 6270 0 0 {name=l3486 sig_type=std_logic lab=WL_27_I}
C {devices/lab_pin.sym} 3280 6210 0 0 {name=l3487 sig_type=std_logic lab=PL_27_I}
C {devices/lab_pin.sym} 3280 6270 0 0 {name=l3488 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 6240 0 0 {name=Xc_27_8
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 6210 0 0 {name=l3489 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 6270 0 0 {name=l3490 sig_type=std_logic lab=WL_27_I}
C {devices/lab_pin.sym} 3680 6210 0 0 {name=l3491 sig_type=std_logic lab=PL_27_I}
C {devices/lab_pin.sym} 3680 6270 0 0 {name=l3492 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 6240 0 0 {name=Xc_27_9
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 6210 0 0 {name=l3493 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 6270 0 0 {name=l3494 sig_type=std_logic lab=WL_27_I}
C {devices/lab_pin.sym} 4080 6210 0 0 {name=l3495 sig_type=std_logic lab=PL_27_I}
C {devices/lab_pin.sym} 4080 6270 0 0 {name=l3496 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 6240 0 0 {name=Xc_27_10
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 6210 0 0 {name=l3497 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 6270 0 0 {name=l3498 sig_type=std_logic lab=WL_27_I}
C {devices/lab_pin.sym} 4480 6210 0 0 {name=l3499 sig_type=std_logic lab=PL_27_I}
C {devices/lab_pin.sym} 4480 6270 0 0 {name=l3500 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 6240 0 0 {name=Xc_27_11
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 6210 0 0 {name=l3501 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 6270 0 0 {name=l3502 sig_type=std_logic lab=WL_27_II}
C {devices/lab_pin.sym} 4880 6210 0 0 {name=l3503 sig_type=std_logic lab=PL_27_II}
C {devices/lab_pin.sym} 4880 6270 0 0 {name=l3504 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 6240 0 0 {name=Xc_27_12
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 6210 0 0 {name=l3505 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 6270 0 0 {name=l3506 sig_type=std_logic lab=WL_27_II}
C {devices/lab_pin.sym} 5280 6210 0 0 {name=l3507 sig_type=std_logic lab=PL_27_II}
C {devices/lab_pin.sym} 5280 6270 0 0 {name=l3508 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 6240 0 0 {name=Xc_27_13
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 6210 0 0 {name=l3509 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 6270 0 0 {name=l3510 sig_type=std_logic lab=WL_27_II}
C {devices/lab_pin.sym} 5680 6210 0 0 {name=l3511 sig_type=std_logic lab=PL_27_II}
C {devices/lab_pin.sym} 5680 6270 0 0 {name=l3512 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 6240 0 0 {name=Xc_27_14
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 6210 0 0 {name=l3513 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 6270 0 0 {name=l3514 sig_type=std_logic lab=WL_27_II}
C {devices/lab_pin.sym} 6080 6210 0 0 {name=l3515 sig_type=std_logic lab=PL_27_II}
C {devices/lab_pin.sym} 6080 6270 0 0 {name=l3516 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 6240 0 0 {name=Xc_27_15
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 6210 0 0 {name=l3517 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 6270 0 0 {name=l3518 sig_type=std_logic lab=WL_27_II}
C {devices/lab_pin.sym} 6480 6210 0 0 {name=l3519 sig_type=std_logic lab=PL_27_II}
C {devices/lab_pin.sym} 6480 6270 0 0 {name=l3520 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 6240 0 0 {name=Xc_27_16
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 6210 0 0 {name=l3521 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 6270 0 0 {name=l3522 sig_type=std_logic lab=WL_27_II}
C {devices/lab_pin.sym} 6880 6210 0 0 {name=l3523 sig_type=std_logic lab=PL_27_II}
C {devices/lab_pin.sym} 6880 6270 0 0 {name=l3524 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 6240 0 0 {name=Xc_27_17
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 6210 0 0 {name=l3525 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 6270 0 0 {name=l3526 sig_type=std_logic lab=WL_27_II}
C {devices/lab_pin.sym} 7280 6210 0 0 {name=l3527 sig_type=std_logic lab=PL_27_II}
C {devices/lab_pin.sym} 7280 6270 0 0 {name=l3528 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 6240 0 0 {name=Xc_27_18
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 6210 0 0 {name=l3529 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 6270 0 0 {name=l3530 sig_type=std_logic lab=WL_27_II}
C {devices/lab_pin.sym} 7680 6210 0 0 {name=l3531 sig_type=std_logic lab=PL_27_II}
C {devices/lab_pin.sym} 7680 6270 0 0 {name=l3532 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 6240 0 0 {name=Xc_27_19
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 6210 0 0 {name=l3533 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 6270 0 0 {name=l3534 sig_type=std_logic lab=WL_27_II}
C {devices/lab_pin.sym} 8080 6210 0 0 {name=l3535 sig_type=std_logic lab=PL_27_II}
C {devices/lab_pin.sym} 8080 6270 0 0 {name=l3536 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 6240 0 0 {name=Xc_27_20
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 6210 0 0 {name=l3537 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 6270 0 0 {name=l3538 sig_type=std_logic lab=WL_27_II}
C {devices/lab_pin.sym} 8480 6210 0 0 {name=l3539 sig_type=std_logic lab=PL_27_II}
C {devices/lab_pin.sym} 8480 6270 0 0 {name=l3540 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 6240 0 0 {name=Xc_27_21
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 6210 0 0 {name=l3541 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 6270 0 0 {name=l3542 sig_type=std_logic lab=WL_27_II}
C {devices/lab_pin.sym} 8880 6210 0 0 {name=l3543 sig_type=std_logic lab=PL_27_II}
C {devices/lab_pin.sym} 8880 6270 0 0 {name=l3544 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 6240 0 0 {name=Xc_27_22
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 6210 0 0 {name=l3545 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 6270 0 0 {name=l3546 sig_type=std_logic lab=WL_27_III}
C {devices/lab_pin.sym} 9280 6210 0 0 {name=l3547 sig_type=std_logic lab=PL_27_III}
C {devices/lab_pin.sym} 9280 6270 0 0 {name=l3548 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 6240 0 0 {name=Xc_27_23
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 6210 0 0 {name=l3549 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 6270 0 0 {name=l3550 sig_type=std_logic lab=WL_27_III}
C {devices/lab_pin.sym} 9680 6210 0 0 {name=l3551 sig_type=std_logic lab=PL_27_III}
C {devices/lab_pin.sym} 9680 6270 0 0 {name=l3552 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 6240 0 0 {name=Xc_27_24
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 6210 0 0 {name=l3553 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 6270 0 0 {name=l3554 sig_type=std_logic lab=WL_27_III}
C {devices/lab_pin.sym} 10080 6210 0 0 {name=l3555 sig_type=std_logic lab=PL_27_III}
C {devices/lab_pin.sym} 10080 6270 0 0 {name=l3556 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 6240 0 0 {name=Xc_27_25
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 6210 0 0 {name=l3557 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 6270 0 0 {name=l3558 sig_type=std_logic lab=WL_27_III}
C {devices/lab_pin.sym} 10480 6210 0 0 {name=l3559 sig_type=std_logic lab=PL_27_III}
C {devices/lab_pin.sym} 10480 6270 0 0 {name=l3560 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 6240 0 0 {name=Xc_27_26
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 6210 0 0 {name=l3561 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 6270 0 0 {name=l3562 sig_type=std_logic lab=WL_27_III}
C {devices/lab_pin.sym} 10880 6210 0 0 {name=l3563 sig_type=std_logic lab=PL_27_III}
C {devices/lab_pin.sym} 10880 6270 0 0 {name=l3564 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 6240 0 0 {name=Xc_27_27
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 6210 0 0 {name=l3565 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 6270 0 0 {name=l3566 sig_type=std_logic lab=WL_27_III}
C {devices/lab_pin.sym} 11280 6210 0 0 {name=l3567 sig_type=std_logic lab=PL_27_III}
C {devices/lab_pin.sym} 11280 6270 0 0 {name=l3568 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 6240 0 0 {name=Xc_27_28
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 6210 0 0 {name=l3569 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 6270 0 0 {name=l3570 sig_type=std_logic lab=WL_27_III}
C {devices/lab_pin.sym} 11680 6210 0 0 {name=l3571 sig_type=std_logic lab=PL_27_III}
C {devices/lab_pin.sym} 11680 6270 0 0 {name=l3572 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 6240 0 0 {name=Xc_27_29
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 6210 0 0 {name=l3573 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 6270 0 0 {name=l3574 sig_type=std_logic lab=WL_27_III}
C {devices/lab_pin.sym} 12080 6210 0 0 {name=l3575 sig_type=std_logic lab=PL_27_III}
C {devices/lab_pin.sym} 12080 6270 0 0 {name=l3576 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 6240 0 0 {name=Xc_27_30
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 6210 0 0 {name=l3577 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 6270 0 0 {name=l3578 sig_type=std_logic lab=WL_27_III}
C {devices/lab_pin.sym} 12480 6210 0 0 {name=l3579 sig_type=std_logic lab=PL_27_III}
C {devices/lab_pin.sym} 12480 6270 0 0 {name=l3580 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 6240 0 0 {name=Xc_27_31
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 6210 0 0 {name=l3581 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 6270 0 0 {name=l3582 sig_type=std_logic lab=WL_27_III}
C {devices/lab_pin.sym} 12880 6210 0 0 {name=l3583 sig_type=std_logic lab=PL_27_III}
C {devices/lab_pin.sym} 12880 6270 0 0 {name=l3584 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 6460 0 0 {name=Xc_28_0
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 6430 0 0 {name=l3585 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 6490 0 0 {name=l3586 sig_type=std_logic lab=WL_28_I}
C {devices/lab_pin.sym} 480 6430 0 0 {name=l3587 sig_type=std_logic lab=PL_28_I}
C {devices/lab_pin.sym} 480 6490 0 0 {name=l3588 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 6460 0 0 {name=Xc_28_1
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 6430 0 0 {name=l3589 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 6490 0 0 {name=l3590 sig_type=std_logic lab=WL_28_I}
C {devices/lab_pin.sym} 880 6430 0 0 {name=l3591 sig_type=std_logic lab=PL_28_I}
C {devices/lab_pin.sym} 880 6490 0 0 {name=l3592 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 6460 0 0 {name=Xc_28_2
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 6430 0 0 {name=l3593 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 6490 0 0 {name=l3594 sig_type=std_logic lab=WL_28_I}
C {devices/lab_pin.sym} 1280 6430 0 0 {name=l3595 sig_type=std_logic lab=PL_28_I}
C {devices/lab_pin.sym} 1280 6490 0 0 {name=l3596 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 6460 0 0 {name=Xc_28_3
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 6430 0 0 {name=l3597 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 6490 0 0 {name=l3598 sig_type=std_logic lab=WL_28_I}
C {devices/lab_pin.sym} 1680 6430 0 0 {name=l3599 sig_type=std_logic lab=PL_28_I}
C {devices/lab_pin.sym} 1680 6490 0 0 {name=l3600 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 6460 0 0 {name=Xc_28_4
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 6430 0 0 {name=l3601 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 6490 0 0 {name=l3602 sig_type=std_logic lab=WL_28_I}
C {devices/lab_pin.sym} 2080 6430 0 0 {name=l3603 sig_type=std_logic lab=PL_28_I}
C {devices/lab_pin.sym} 2080 6490 0 0 {name=l3604 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 6460 0 0 {name=Xc_28_5
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 6430 0 0 {name=l3605 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 6490 0 0 {name=l3606 sig_type=std_logic lab=WL_28_I}
C {devices/lab_pin.sym} 2480 6430 0 0 {name=l3607 sig_type=std_logic lab=PL_28_I}
C {devices/lab_pin.sym} 2480 6490 0 0 {name=l3608 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 6460 0 0 {name=Xc_28_6
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 6430 0 0 {name=l3609 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 6490 0 0 {name=l3610 sig_type=std_logic lab=WL_28_I}
C {devices/lab_pin.sym} 2880 6430 0 0 {name=l3611 sig_type=std_logic lab=PL_28_I}
C {devices/lab_pin.sym} 2880 6490 0 0 {name=l3612 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 6460 0 0 {name=Xc_28_7
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 6430 0 0 {name=l3613 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 6490 0 0 {name=l3614 sig_type=std_logic lab=WL_28_I}
C {devices/lab_pin.sym} 3280 6430 0 0 {name=l3615 sig_type=std_logic lab=PL_28_I}
C {devices/lab_pin.sym} 3280 6490 0 0 {name=l3616 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 6460 0 0 {name=Xc_28_8
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 6430 0 0 {name=l3617 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 6490 0 0 {name=l3618 sig_type=std_logic lab=WL_28_I}
C {devices/lab_pin.sym} 3680 6430 0 0 {name=l3619 sig_type=std_logic lab=PL_28_I}
C {devices/lab_pin.sym} 3680 6490 0 0 {name=l3620 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 6460 0 0 {name=Xc_28_9
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 6430 0 0 {name=l3621 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 6490 0 0 {name=l3622 sig_type=std_logic lab=WL_28_I}
C {devices/lab_pin.sym} 4080 6430 0 0 {name=l3623 sig_type=std_logic lab=PL_28_I}
C {devices/lab_pin.sym} 4080 6490 0 0 {name=l3624 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 6460 0 0 {name=Xc_28_10
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 6430 0 0 {name=l3625 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 6490 0 0 {name=l3626 sig_type=std_logic lab=WL_28_I}
C {devices/lab_pin.sym} 4480 6430 0 0 {name=l3627 sig_type=std_logic lab=PL_28_I}
C {devices/lab_pin.sym} 4480 6490 0 0 {name=l3628 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 6460 0 0 {name=Xc_28_11
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 6430 0 0 {name=l3629 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 6490 0 0 {name=l3630 sig_type=std_logic lab=WL_28_II}
C {devices/lab_pin.sym} 4880 6430 0 0 {name=l3631 sig_type=std_logic lab=PL_28_II}
C {devices/lab_pin.sym} 4880 6490 0 0 {name=l3632 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 6460 0 0 {name=Xc_28_12
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 6430 0 0 {name=l3633 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 6490 0 0 {name=l3634 sig_type=std_logic lab=WL_28_II}
C {devices/lab_pin.sym} 5280 6430 0 0 {name=l3635 sig_type=std_logic lab=PL_28_II}
C {devices/lab_pin.sym} 5280 6490 0 0 {name=l3636 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 6460 0 0 {name=Xc_28_13
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 6430 0 0 {name=l3637 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 6490 0 0 {name=l3638 sig_type=std_logic lab=WL_28_II}
C {devices/lab_pin.sym} 5680 6430 0 0 {name=l3639 sig_type=std_logic lab=PL_28_II}
C {devices/lab_pin.sym} 5680 6490 0 0 {name=l3640 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 6460 0 0 {name=Xc_28_14
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 6430 0 0 {name=l3641 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 6490 0 0 {name=l3642 sig_type=std_logic lab=WL_28_II}
C {devices/lab_pin.sym} 6080 6430 0 0 {name=l3643 sig_type=std_logic lab=PL_28_II}
C {devices/lab_pin.sym} 6080 6490 0 0 {name=l3644 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 6460 0 0 {name=Xc_28_15
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 6430 0 0 {name=l3645 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 6490 0 0 {name=l3646 sig_type=std_logic lab=WL_28_II}
C {devices/lab_pin.sym} 6480 6430 0 0 {name=l3647 sig_type=std_logic lab=PL_28_II}
C {devices/lab_pin.sym} 6480 6490 0 0 {name=l3648 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 6460 0 0 {name=Xc_28_16
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 6430 0 0 {name=l3649 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 6490 0 0 {name=l3650 sig_type=std_logic lab=WL_28_II}
C {devices/lab_pin.sym} 6880 6430 0 0 {name=l3651 sig_type=std_logic lab=PL_28_II}
C {devices/lab_pin.sym} 6880 6490 0 0 {name=l3652 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 6460 0 0 {name=Xc_28_17
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 6430 0 0 {name=l3653 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 6490 0 0 {name=l3654 sig_type=std_logic lab=WL_28_II}
C {devices/lab_pin.sym} 7280 6430 0 0 {name=l3655 sig_type=std_logic lab=PL_28_II}
C {devices/lab_pin.sym} 7280 6490 0 0 {name=l3656 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7600 6460 0 0 {name=Xc_28_18
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7520 6430 0 0 {name=l3657 sig_type=std_logic lab=BL_18}
C {devices/lab_pin.sym} 7520 6490 0 0 {name=l3658 sig_type=std_logic lab=WL_28_II}
C {devices/lab_pin.sym} 7680 6430 0 0 {name=l3659 sig_type=std_logic lab=PL_28_II}
C {devices/lab_pin.sym} 7680 6490 0 0 {name=l3660 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8000 6460 0 0 {name=Xc_28_19
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7920 6430 0 0 {name=l3661 sig_type=std_logic lab=BL_19}
C {devices/lab_pin.sym} 7920 6490 0 0 {name=l3662 sig_type=std_logic lab=WL_28_II}
C {devices/lab_pin.sym} 8080 6430 0 0 {name=l3663 sig_type=std_logic lab=PL_28_II}
C {devices/lab_pin.sym} 8080 6490 0 0 {name=l3664 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8400 6460 0 0 {name=Xc_28_20
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8320 6430 0 0 {name=l3665 sig_type=std_logic lab=BL_20}
C {devices/lab_pin.sym} 8320 6490 0 0 {name=l3666 sig_type=std_logic lab=WL_28_II}
C {devices/lab_pin.sym} 8480 6430 0 0 {name=l3667 sig_type=std_logic lab=PL_28_II}
C {devices/lab_pin.sym} 8480 6490 0 0 {name=l3668 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 8800 6460 0 0 {name=Xc_28_21
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 8720 6430 0 0 {name=l3669 sig_type=std_logic lab=BL_21}
C {devices/lab_pin.sym} 8720 6490 0 0 {name=l3670 sig_type=std_logic lab=WL_28_II}
C {devices/lab_pin.sym} 8880 6430 0 0 {name=l3671 sig_type=std_logic lab=PL_28_II}
C {devices/lab_pin.sym} 8880 6490 0 0 {name=l3672 sig_type=std_logic lab=VSS}
C {cell_candidate3.sym} 9200 6460 0 0 {name=Xc_28_22
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9120 6430 0 0 {name=l3673 sig_type=std_logic lab=BL_22}
C {devices/lab_pin.sym} 9120 6490 0 0 {name=l3674 sig_type=std_logic lab=WL_28_III}
C {devices/lab_pin.sym} 9280 6430 0 0 {name=l3675 sig_type=std_logic lab=PL_28_III}
C {devices/lab_pin.sym} 9280 6490 0 0 {name=l3676 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 9600 6460 0 0 {name=Xc_28_23
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9520 6430 0 0 {name=l3677 sig_type=std_logic lab=BL_23}
C {devices/lab_pin.sym} 9520 6490 0 0 {name=l3678 sig_type=std_logic lab=WL_28_III}
C {devices/lab_pin.sym} 9680 6430 0 0 {name=l3679 sig_type=std_logic lab=PL_28_III}
C {devices/lab_pin.sym} 9680 6490 0 0 {name=l3680 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10000 6460 0 0 {name=Xc_28_24
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 9920 6430 0 0 {name=l3681 sig_type=std_logic lab=BL_24}
C {devices/lab_pin.sym} 9920 6490 0 0 {name=l3682 sig_type=std_logic lab=WL_28_III}
C {devices/lab_pin.sym} 10080 6430 0 0 {name=l3683 sig_type=std_logic lab=PL_28_III}
C {devices/lab_pin.sym} 10080 6490 0 0 {name=l3684 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10400 6460 0 0 {name=Xc_28_25
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10320 6430 0 0 {name=l3685 sig_type=std_logic lab=BL_25}
C {devices/lab_pin.sym} 10320 6490 0 0 {name=l3686 sig_type=std_logic lab=WL_28_III}
C {devices/lab_pin.sym} 10480 6430 0 0 {name=l3687 sig_type=std_logic lab=PL_28_III}
C {devices/lab_pin.sym} 10480 6490 0 0 {name=l3688 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 10800 6460 0 0 {name=Xc_28_26
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 10720 6430 0 0 {name=l3689 sig_type=std_logic lab=BL_26}
C {devices/lab_pin.sym} 10720 6490 0 0 {name=l3690 sig_type=std_logic lab=WL_28_III}
C {devices/lab_pin.sym} 10880 6430 0 0 {name=l3691 sig_type=std_logic lab=PL_28_III}
C {devices/lab_pin.sym} 10880 6490 0 0 {name=l3692 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11200 6460 0 0 {name=Xc_28_27
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11120 6430 0 0 {name=l3693 sig_type=std_logic lab=BL_27}
C {devices/lab_pin.sym} 11120 6490 0 0 {name=l3694 sig_type=std_logic lab=WL_28_III}
C {devices/lab_pin.sym} 11280 6430 0 0 {name=l3695 sig_type=std_logic lab=PL_28_III}
C {devices/lab_pin.sym} 11280 6490 0 0 {name=l3696 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 11600 6460 0 0 {name=Xc_28_28
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11520 6430 0 0 {name=l3697 sig_type=std_logic lab=BL_28}
C {devices/lab_pin.sym} 11520 6490 0 0 {name=l3698 sig_type=std_logic lab=WL_28_III}
C {devices/lab_pin.sym} 11680 6430 0 0 {name=l3699 sig_type=std_logic lab=PL_28_III}
C {devices/lab_pin.sym} 11680 6490 0 0 {name=l3700 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12000 6460 0 0 {name=Xc_28_29
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 11920 6430 0 0 {name=l3701 sig_type=std_logic lab=BL_29}
C {devices/lab_pin.sym} 11920 6490 0 0 {name=l3702 sig_type=std_logic lab=WL_28_III}
C {devices/lab_pin.sym} 12080 6430 0 0 {name=l3703 sig_type=std_logic lab=PL_28_III}
C {devices/lab_pin.sym} 12080 6490 0 0 {name=l3704 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12400 6460 0 0 {name=Xc_28_30
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12320 6430 0 0 {name=l3705 sig_type=std_logic lab=BL_30}
C {devices/lab_pin.sym} 12320 6490 0 0 {name=l3706 sig_type=std_logic lab=WL_28_III}
C {devices/lab_pin.sym} 12480 6430 0 0 {name=l3707 sig_type=std_logic lab=PL_28_III}
C {devices/lab_pin.sym} 12480 6490 0 0 {name=l3708 sig_type=std_logic lab=VDDH_III}
C {cell_candidate3.sym} 12800 6460 0 0 {name=Xc_28_31
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.55u
m=1}
C {devices/lab_pin.sym} 12720 6430 0 0 {name=l3709 sig_type=std_logic lab=BL_31}
C {devices/lab_pin.sym} 12720 6490 0 0 {name=l3710 sig_type=std_logic lab=WL_28_III}
C {devices/lab_pin.sym} 12880 6430 0 0 {name=l3711 sig_type=std_logic lab=PL_28_III}
C {devices/lab_pin.sym} 12880 6490 0 0 {name=l3712 sig_type=std_logic lab=VDDH_III}
C {cell_candidate1.sym} 400 6680 0 0 {name=Xc_29_0
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 6650 0 0 {name=l3713 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 6710 0 0 {name=l3714 sig_type=std_logic lab=WL_29_I}
C {devices/lab_pin.sym} 480 6650 0 0 {name=l3715 sig_type=std_logic lab=PL_29_I}
C {devices/lab_pin.sym} 480 6710 0 0 {name=l3716 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 6680 0 0 {name=Xc_29_1
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 6650 0 0 {name=l3717 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 6710 0 0 {name=l3718 sig_type=std_logic lab=WL_29_I}
C {devices/lab_pin.sym} 880 6650 0 0 {name=l3719 sig_type=std_logic lab=PL_29_I}
C {devices/lab_pin.sym} 880 6710 0 0 {name=l3720 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 6680 0 0 {name=Xc_29_2
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 6650 0 0 {name=l3721 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 6710 0 0 {name=l3722 sig_type=std_logic lab=WL_29_I}
C {devices/lab_pin.sym} 1280 6650 0 0 {name=l3723 sig_type=std_logic lab=PL_29_I}
C {devices/lab_pin.sym} 1280 6710 0 0 {name=l3724 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 6680 0 0 {name=Xc_29_3
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 6650 0 0 {name=l3725 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 6710 0 0 {name=l3726 sig_type=std_logic lab=WL_29_I}
C {devices/lab_pin.sym} 1680 6650 0 0 {name=l3727 sig_type=std_logic lab=PL_29_I}
C {devices/lab_pin.sym} 1680 6710 0 0 {name=l3728 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 6680 0 0 {name=Xc_29_4
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 6650 0 0 {name=l3729 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 6710 0 0 {name=l3730 sig_type=std_logic lab=WL_29_I}
C {devices/lab_pin.sym} 2080 6650 0 0 {name=l3731 sig_type=std_logic lab=PL_29_I}
C {devices/lab_pin.sym} 2080 6710 0 0 {name=l3732 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 6680 0 0 {name=Xc_29_5
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 6650 0 0 {name=l3733 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 6710 0 0 {name=l3734 sig_type=std_logic lab=WL_29_I}
C {devices/lab_pin.sym} 2480 6650 0 0 {name=l3735 sig_type=std_logic lab=PL_29_I}
C {devices/lab_pin.sym} 2480 6710 0 0 {name=l3736 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 6680 0 0 {name=Xc_29_6
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 6650 0 0 {name=l3737 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 6710 0 0 {name=l3738 sig_type=std_logic lab=WL_29_I}
C {devices/lab_pin.sym} 2880 6650 0 0 {name=l3739 sig_type=std_logic lab=PL_29_I}
C {devices/lab_pin.sym} 2880 6710 0 0 {name=l3740 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 6680 0 0 {name=Xc_29_7
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 6650 0 0 {name=l3741 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 6710 0 0 {name=l3742 sig_type=std_logic lab=WL_29_I}
C {devices/lab_pin.sym} 3280 6650 0 0 {name=l3743 sig_type=std_logic lab=PL_29_I}
C {devices/lab_pin.sym} 3280 6710 0 0 {name=l3744 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 6680 0 0 {name=Xc_29_8
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 6650 0 0 {name=l3745 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 6710 0 0 {name=l3746 sig_type=std_logic lab=WL_29_I}
C {devices/lab_pin.sym} 3680 6650 0 0 {name=l3747 sig_type=std_logic lab=PL_29_I}
C {devices/lab_pin.sym} 3680 6710 0 0 {name=l3748 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 6680 0 0 {name=Xc_29_9
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 6650 0 0 {name=l3749 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 6710 0 0 {name=l3750 sig_type=std_logic lab=WL_29_I}
C {devices/lab_pin.sym} 4080 6650 0 0 {name=l3751 sig_type=std_logic lab=PL_29_I}
C {devices/lab_pin.sym} 4080 6710 0 0 {name=l3752 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 6680 0 0 {name=Xc_29_10
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 6650 0 0 {name=l3753 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 6710 0 0 {name=l3754 sig_type=std_logic lab=WL_29_I}
C {devices/lab_pin.sym} 4480 6650 0 0 {name=l3755 sig_type=std_logic lab=PL_29_I}
C {devices/lab_pin.sym} 4480 6710 0 0 {name=l3756 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 4800 6680 0 0 {name=Xc_29_11
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 4720 6650 0 0 {name=l3757 sig_type=std_logic lab=BL_11}
C {devices/lab_pin.sym} 4720 6710 0 0 {name=l3758 sig_type=std_logic lab=WL_29_II}
C {devices/lab_pin.sym} 4880 6650 0 0 {name=l3759 sig_type=std_logic lab=PL_29_II}
C {devices/lab_pin.sym} 4880 6710 0 0 {name=l3760 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5200 6680 0 0 {name=Xc_29_12
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5120 6650 0 0 {name=l3761 sig_type=std_logic lab=BL_12}
C {devices/lab_pin.sym} 5120 6710 0 0 {name=l3762 sig_type=std_logic lab=WL_29_II}
C {devices/lab_pin.sym} 5280 6650 0 0 {name=l3763 sig_type=std_logic lab=PL_29_II}
C {devices/lab_pin.sym} 5280 6710 0 0 {name=l3764 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 5600 6680 0 0 {name=Xc_29_13
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5520 6650 0 0 {name=l3765 sig_type=std_logic lab=BL_13}
C {devices/lab_pin.sym} 5520 6710 0 0 {name=l3766 sig_type=std_logic lab=WL_29_II}
C {devices/lab_pin.sym} 5680 6650 0 0 {name=l3767 sig_type=std_logic lab=PL_29_II}
C {devices/lab_pin.sym} 5680 6710 0 0 {name=l3768 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6000 6680 0 0 {name=Xc_29_14
wcap=1e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 5920 6650 0 0 {name=l3769 sig_type=std_logic lab=BL_14}
C {devices/lab_pin.sym} 5920 6710 0 0 {name=l3770 sig_type=std_logic lab=WL_29_II}
C {devices/lab_pin.sym} 6080 6650 0 0 {name=l3771 sig_type=std_logic lab=PL_29_II}
C {devices/lab_pin.sym} 6080 6710 0 0 {name=l3772 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6400 6680 0 0 {name=Xc_29_15
wcap=2e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6320 6650 0 0 {name=l3773 sig_type=std_logic lab=BL_15}
C {devices/lab_pin.sym} 6320 6710 0 0 {name=l3774 sig_type=std_logic lab=WL_29_II}
C {devices/lab_pin.sym} 6480 6650 0 0 {name=l3775 sig_type=std_logic lab=PL_29_II}
C {devices/lab_pin.sym} 6480 6710 0 0 {name=l3776 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 6800 6680 0 0 {name=Xc_29_16
wcap=1e-6
lcap=1e-6
wacc=25u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 6720 6650 0 0 {name=l3777 sig_type=std_logic lab=BL_16}
C {devices/lab_pin.sym} 6720 6710 0 0 {name=l3778 sig_type=std_logic lab=WL_29_II}
C {devices/lab_pin.sym} 6880 6650 0 0 {name=l3779 sig_type=std_logic lab=PL_29_II}
C {devices/lab_pin.sym} 6880 6710 0 0 {name=l3780 sig_type=std_logic lab=VSS}
C {cell_candidate2.sym} 7200 6680 0 0 {name=Xc_29_17
wcap=2e-6
lcap=1e-6
wacc=50u
lacc=0.60u
m=1}
C {devices/lab_pin.sym} 7120 6650 0 0 {name=l3781 sig_type=std_logic lab=BL_17}
C {devices/lab_pin.sym} 7120 6710 0 0 {name=l3782 sig_type=std_logic lab=WL_29_II}
C {devices/lab_pin.sym} 7280 6650 0 0 {name=l3783 sig_type=std_logic lab=PL_29_II}
