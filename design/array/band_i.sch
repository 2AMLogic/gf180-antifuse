v {xschem version=3.4.7 file_version=1.2

* gf180-antifuse: band_i - GENERATED by design/gen_array.py. Do not hand-edit;
* edit the generator and rerun design/regen-netlists.sh.
*
* Rows 0..3, columns 0..10 of the N=32 array (absolute coordinates),
* with the row/column local high-voltage addressing stage of
* spec/architecture.md 1.1 (level shifter -> HV pass-gate).
*
* Per-cell wcap/lcap/wacc/lacc and candidate type follow the region map in
* spec/split-axis-plan.md; design/check-array.py fails if they drift.
*
* Nets: BL_<c> column bit line; WL_<r>_<band> / PL_<r>_<band> word / plate line
* of one row segment; BLG_<band> / PLG_<band> per-band global bus the (out of
* scope) program / read legs attach to; CSEL_<c> / RSEL_<r> single-ended
* one-hot selects from the digital partition; VDDH_<band> level-shifter rail.
* Candidate 3's word line is active-low (PMOS access) and its cell VB is the
* band's VDDH rail (n-well tie at the most positive potential).
*
* PROVISIONAL CONVENTIONS (not ratified) - open items for the operator,
* numbered (a)-(e) with alternatives and consequences in design/README.md
* ("PROVISIONAL resolutions - open items for the operator"):
*   (a) 'min' geometry = the cell subckt placeholder defaults; '2x' = width x2.
*   (b) interleave phase: cap (r+c') mod 2, access (r//2+c'//2) mod 2,
*       band-relative column c'.
*   (c) band axis = column; row stage per (row, band); per-band BLG/PLG/VDDH.
*   (d) Region II level shifters/pass-gates use the 10 V asymmetric pair.
*   (e) NMOS pass-gate gate rail = VDDH (passes at most VDDH - Vth).
}
G {}
K {}
V {}
S {}
E {}
C {cell_candidate1.sym} 400 300 0 0 {name=Xc_0_0
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 270 0 0 {name=l1 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 330 0 0 {name=l2 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 480 270 0 0 {name=l3 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} 480 330 0 0 {name=l4 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 300 0 0 {name=Xc_0_1
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 270 0 0 {name=l5 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 330 0 0 {name=l6 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 880 270 0 0 {name=l7 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} 880 330 0 0 {name=l8 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 300 0 0 {name=Xc_0_2
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 270 0 0 {name=l9 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 330 0 0 {name=l10 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 1280 270 0 0 {name=l11 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} 1280 330 0 0 {name=l12 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 300 0 0 {name=Xc_0_3
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 270 0 0 {name=l13 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 330 0 0 {name=l14 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 1680 270 0 0 {name=l15 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} 1680 330 0 0 {name=l16 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 300 0 0 {name=Xc_0_4
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 270 0 0 {name=l17 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 330 0 0 {name=l18 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 2080 270 0 0 {name=l19 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} 2080 330 0 0 {name=l20 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 300 0 0 {name=Xc_0_5
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 270 0 0 {name=l21 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 330 0 0 {name=l22 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 2480 270 0 0 {name=l23 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} 2480 330 0 0 {name=l24 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 300 0 0 {name=Xc_0_6
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 270 0 0 {name=l25 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 330 0 0 {name=l26 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 2880 270 0 0 {name=l27 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} 2880 330 0 0 {name=l28 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 300 0 0 {name=Xc_0_7
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 270 0 0 {name=l29 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 330 0 0 {name=l30 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 3280 270 0 0 {name=l31 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} 3280 330 0 0 {name=l32 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 300 0 0 {name=Xc_0_8
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 270 0 0 {name=l33 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 330 0 0 {name=l34 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 3680 270 0 0 {name=l35 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} 3680 330 0 0 {name=l36 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 300 0 0 {name=Xc_0_9
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 270 0 0 {name=l37 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 330 0 0 {name=l38 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 4080 270 0 0 {name=l39 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} 4080 330 0 0 {name=l40 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 300 0 0 {name=Xc_0_10
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 270 0 0 {name=l41 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 330 0 0 {name=l42 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 4480 270 0 0 {name=l43 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} 4480 330 0 0 {name=l44 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 400 520 0 0 {name=Xc_1_0
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 490 0 0 {name=l45 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 550 0 0 {name=l46 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 480 490 0 0 {name=l47 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} 480 550 0 0 {name=l48 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 520 0 0 {name=Xc_1_1
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 490 0 0 {name=l49 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 550 0 0 {name=l50 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 880 490 0 0 {name=l51 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} 880 550 0 0 {name=l52 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 520 0 0 {name=Xc_1_2
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 490 0 0 {name=l53 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 550 0 0 {name=l54 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 1280 490 0 0 {name=l55 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} 1280 550 0 0 {name=l56 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 520 0 0 {name=Xc_1_3
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 490 0 0 {name=l57 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 550 0 0 {name=l58 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 1680 490 0 0 {name=l59 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} 1680 550 0 0 {name=l60 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 520 0 0 {name=Xc_1_4
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 490 0 0 {name=l61 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 550 0 0 {name=l62 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 2080 490 0 0 {name=l63 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} 2080 550 0 0 {name=l64 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 520 0 0 {name=Xc_1_5
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 490 0 0 {name=l65 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 550 0 0 {name=l66 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 2480 490 0 0 {name=l67 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} 2480 550 0 0 {name=l68 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 520 0 0 {name=Xc_1_6
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 490 0 0 {name=l69 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 550 0 0 {name=l70 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 2880 490 0 0 {name=l71 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} 2880 550 0 0 {name=l72 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 520 0 0 {name=Xc_1_7
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 490 0 0 {name=l73 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 550 0 0 {name=l74 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 3280 490 0 0 {name=l75 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} 3280 550 0 0 {name=l76 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 520 0 0 {name=Xc_1_8
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 490 0 0 {name=l77 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 550 0 0 {name=l78 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 3680 490 0 0 {name=l79 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} 3680 550 0 0 {name=l80 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 520 0 0 {name=Xc_1_9
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 490 0 0 {name=l81 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 550 0 0 {name=l82 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 4080 490 0 0 {name=l83 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} 4080 550 0 0 {name=l84 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 520 0 0 {name=Xc_1_10
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 490 0 0 {name=l85 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 550 0 0 {name=l86 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 4480 490 0 0 {name=l87 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} 4480 550 0 0 {name=l88 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 400 740 0 0 {name=Xc_2_0
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 710 0 0 {name=l89 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 770 0 0 {name=l90 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 480 710 0 0 {name=l91 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} 480 770 0 0 {name=l92 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 740 0 0 {name=Xc_2_1
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 710 0 0 {name=l93 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 770 0 0 {name=l94 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 880 710 0 0 {name=l95 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} 880 770 0 0 {name=l96 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 740 0 0 {name=Xc_2_2
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 710 0 0 {name=l97 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 770 0 0 {name=l98 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 1280 710 0 0 {name=l99 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} 1280 770 0 0 {name=l100 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 740 0 0 {name=Xc_2_3
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 710 0 0 {name=l101 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 770 0 0 {name=l102 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 1680 710 0 0 {name=l103 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} 1680 770 0 0 {name=l104 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 740 0 0 {name=Xc_2_4
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 710 0 0 {name=l105 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 770 0 0 {name=l106 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 2080 710 0 0 {name=l107 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} 2080 770 0 0 {name=l108 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 740 0 0 {name=Xc_2_5
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 710 0 0 {name=l109 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 770 0 0 {name=l110 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 2480 710 0 0 {name=l111 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} 2480 770 0 0 {name=l112 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 740 0 0 {name=Xc_2_6
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 710 0 0 {name=l113 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 770 0 0 {name=l114 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 2880 710 0 0 {name=l115 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} 2880 770 0 0 {name=l116 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 740 0 0 {name=Xc_2_7
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 710 0 0 {name=l117 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 770 0 0 {name=l118 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 3280 710 0 0 {name=l119 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} 3280 770 0 0 {name=l120 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 740 0 0 {name=Xc_2_8
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 710 0 0 {name=l121 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 770 0 0 {name=l122 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 3680 710 0 0 {name=l123 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} 3680 770 0 0 {name=l124 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 740 0 0 {name=Xc_2_9
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 710 0 0 {name=l125 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 770 0 0 {name=l126 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 4080 710 0 0 {name=l127 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} 4080 770 0 0 {name=l128 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 740 0 0 {name=Xc_2_10
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 710 0 0 {name=l129 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 770 0 0 {name=l130 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 4480 710 0 0 {name=l131 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} 4480 770 0 0 {name=l132 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 400 960 0 0 {name=Xc_3_0
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 320 930 0 0 {name=l133 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 320 990 0 0 {name=l134 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 480 930 0 0 {name=l135 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} 480 990 0 0 {name=l136 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 800 960 0 0 {name=Xc_3_1
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 720 930 0 0 {name=l137 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 720 990 0 0 {name=l138 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 880 930 0 0 {name=l139 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} 880 990 0 0 {name=l140 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1200 960 0 0 {name=Xc_3_2
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1120 930 0 0 {name=l141 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1120 990 0 0 {name=l142 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 1280 930 0 0 {name=l143 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} 1280 990 0 0 {name=l144 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 1600 960 0 0 {name=Xc_3_3
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1520 930 0 0 {name=l145 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1520 990 0 0 {name=l146 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 1680 930 0 0 {name=l147 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} 1680 990 0 0 {name=l148 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2000 960 0 0 {name=Xc_3_4
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 1920 930 0 0 {name=l149 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 1920 990 0 0 {name=l150 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 2080 930 0 0 {name=l151 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} 2080 990 0 0 {name=l152 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2400 960 0 0 {name=Xc_3_5
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2320 930 0 0 {name=l153 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2320 990 0 0 {name=l154 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 2480 930 0 0 {name=l155 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} 2480 990 0 0 {name=l156 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 2800 960 0 0 {name=Xc_3_6
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 2720 930 0 0 {name=l157 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2720 990 0 0 {name=l158 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 2880 930 0 0 {name=l159 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} 2880 990 0 0 {name=l160 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3200 960 0 0 {name=Xc_3_7
wcap=1e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3120 930 0 0 {name=l161 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3120 990 0 0 {name=l162 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 3280 930 0 0 {name=l163 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} 3280 990 0 0 {name=l164 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 3600 960 0 0 {name=Xc_3_8
wcap=2e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3520 930 0 0 {name=l165 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3520 990 0 0 {name=l166 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 3680 930 0 0 {name=l167 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} 3680 990 0 0 {name=l168 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4000 960 0 0 {name=Xc_3_9
wcap=1e-6
lcap=1e-6
wacc=0.6u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 3920 930 0 0 {name=l169 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 3920 990 0 0 {name=l170 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 4080 930 0 0 {name=l171 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} 4080 990 0 0 {name=l172 sig_type=std_logic lab=VSS}
C {cell_candidate1.sym} 4400 960 0 0 {name=Xc_3_10
wcap=2e-6
lcap=1e-6
wacc=0.30u
lacc=0.70u
m=1}
C {devices/lab_pin.sym} 4320 930 0 0 {name=l173 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4320 990 0 0 {name=l174 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 4480 930 0 0 {name=l175 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} 4480 990 0 0 {name=l176 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 400 1280 0 0 {name=XLC_0}
C {devices/lab_pin.sym} 320 1260 0 0 {name=l177 sig_type=std_logic lab=CSEL_0}
C {devices/lab_pin.sym} 320 1280 0 0 {name=l178 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 320 1300 0 0 {name=l179 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 480 1260 0 0 {name=l180 sig_type=std_logic lab=CG_0}
C {devices/lab_pin.sym} 480 1280 0 0 {name=l181 sig_type=std_logic lab=CGB_0}
C {devices/lab_pin.sym} 480 1300 0 0 {name=l182 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 400 1480 0 0 {name=XPC_0}
C {devices/lab_pin.sym} 320 1470 0 0 {name=l183 sig_type=std_logic lab=BLG_I}
C {devices/lab_pin.sym} 320 1490 0 0 {name=l184 sig_type=std_logic lab=CG_0}
C {devices/lab_pin.sym} 480 1470 0 0 {name=l185 sig_type=std_logic lab=BL_0}
C {devices/lab_pin.sym} 480 1490 0 0 {name=l186 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 800 1280 0 0 {name=XLC_1}
C {devices/lab_pin.sym} 720 1260 0 0 {name=l187 sig_type=std_logic lab=CSEL_1}
C {devices/lab_pin.sym} 720 1280 0 0 {name=l188 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 720 1300 0 0 {name=l189 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 880 1260 0 0 {name=l190 sig_type=std_logic lab=CG_1}
C {devices/lab_pin.sym} 880 1280 0 0 {name=l191 sig_type=std_logic lab=CGB_1}
C {devices/lab_pin.sym} 880 1300 0 0 {name=l192 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 800 1480 0 0 {name=XPC_1}
C {devices/lab_pin.sym} 720 1470 0 0 {name=l193 sig_type=std_logic lab=BLG_I}
C {devices/lab_pin.sym} 720 1490 0 0 {name=l194 sig_type=std_logic lab=CG_1}
C {devices/lab_pin.sym} 880 1470 0 0 {name=l195 sig_type=std_logic lab=BL_1}
C {devices/lab_pin.sym} 880 1490 0 0 {name=l196 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 1200 1280 0 0 {name=XLC_2}
C {devices/lab_pin.sym} 1120 1260 0 0 {name=l197 sig_type=std_logic lab=CSEL_2}
C {devices/lab_pin.sym} 1120 1280 0 0 {name=l198 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 1120 1300 0 0 {name=l199 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1280 1260 0 0 {name=l200 sig_type=std_logic lab=CG_2}
C {devices/lab_pin.sym} 1280 1280 0 0 {name=l201 sig_type=std_logic lab=CGB_2}
C {devices/lab_pin.sym} 1280 1300 0 0 {name=l202 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 1200 1480 0 0 {name=XPC_2}
C {devices/lab_pin.sym} 1120 1470 0 0 {name=l203 sig_type=std_logic lab=BLG_I}
C {devices/lab_pin.sym} 1120 1490 0 0 {name=l204 sig_type=std_logic lab=CG_2}
C {devices/lab_pin.sym} 1280 1470 0 0 {name=l205 sig_type=std_logic lab=BL_2}
C {devices/lab_pin.sym} 1280 1490 0 0 {name=l206 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 1600 1280 0 0 {name=XLC_3}
C {devices/lab_pin.sym} 1520 1260 0 0 {name=l207 sig_type=std_logic lab=CSEL_3}
C {devices/lab_pin.sym} 1520 1280 0 0 {name=l208 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 1520 1300 0 0 {name=l209 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 1680 1260 0 0 {name=l210 sig_type=std_logic lab=CG_3}
C {devices/lab_pin.sym} 1680 1280 0 0 {name=l211 sig_type=std_logic lab=CGB_3}
C {devices/lab_pin.sym} 1680 1300 0 0 {name=l212 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 1600 1480 0 0 {name=XPC_3}
C {devices/lab_pin.sym} 1520 1470 0 0 {name=l213 sig_type=std_logic lab=BLG_I}
C {devices/lab_pin.sym} 1520 1490 0 0 {name=l214 sig_type=std_logic lab=CG_3}
C {devices/lab_pin.sym} 1680 1470 0 0 {name=l215 sig_type=std_logic lab=BL_3}
C {devices/lab_pin.sym} 1680 1490 0 0 {name=l216 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 2000 1280 0 0 {name=XLC_4}
C {devices/lab_pin.sym} 1920 1260 0 0 {name=l217 sig_type=std_logic lab=CSEL_4}
C {devices/lab_pin.sym} 1920 1280 0 0 {name=l218 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 1920 1300 0 0 {name=l219 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2080 1260 0 0 {name=l220 sig_type=std_logic lab=CG_4}
C {devices/lab_pin.sym} 2080 1280 0 0 {name=l221 sig_type=std_logic lab=CGB_4}
C {devices/lab_pin.sym} 2080 1300 0 0 {name=l222 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 2000 1480 0 0 {name=XPC_4}
C {devices/lab_pin.sym} 1920 1470 0 0 {name=l223 sig_type=std_logic lab=BLG_I}
C {devices/lab_pin.sym} 1920 1490 0 0 {name=l224 sig_type=std_logic lab=CG_4}
C {devices/lab_pin.sym} 2080 1470 0 0 {name=l225 sig_type=std_logic lab=BL_4}
C {devices/lab_pin.sym} 2080 1490 0 0 {name=l226 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 2400 1280 0 0 {name=XLC_5}
C {devices/lab_pin.sym} 2320 1260 0 0 {name=l227 sig_type=std_logic lab=CSEL_5}
C {devices/lab_pin.sym} 2320 1280 0 0 {name=l228 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 2320 1300 0 0 {name=l229 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2480 1260 0 0 {name=l230 sig_type=std_logic lab=CG_5}
C {devices/lab_pin.sym} 2480 1280 0 0 {name=l231 sig_type=std_logic lab=CGB_5}
C {devices/lab_pin.sym} 2480 1300 0 0 {name=l232 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 2400 1480 0 0 {name=XPC_5}
C {devices/lab_pin.sym} 2320 1470 0 0 {name=l233 sig_type=std_logic lab=BLG_I}
C {devices/lab_pin.sym} 2320 1490 0 0 {name=l234 sig_type=std_logic lab=CG_5}
C {devices/lab_pin.sym} 2480 1470 0 0 {name=l235 sig_type=std_logic lab=BL_5}
C {devices/lab_pin.sym} 2480 1490 0 0 {name=l236 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 2800 1280 0 0 {name=XLC_6}
C {devices/lab_pin.sym} 2720 1260 0 0 {name=l237 sig_type=std_logic lab=CSEL_6}
C {devices/lab_pin.sym} 2720 1280 0 0 {name=l238 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 2720 1300 0 0 {name=l239 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2880 1260 0 0 {name=l240 sig_type=std_logic lab=CG_6}
C {devices/lab_pin.sym} 2880 1280 0 0 {name=l241 sig_type=std_logic lab=CGB_6}
C {devices/lab_pin.sym} 2880 1300 0 0 {name=l242 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 2800 1480 0 0 {name=XPC_6}
C {devices/lab_pin.sym} 2720 1470 0 0 {name=l243 sig_type=std_logic lab=BLG_I}
C {devices/lab_pin.sym} 2720 1490 0 0 {name=l244 sig_type=std_logic lab=CG_6}
C {devices/lab_pin.sym} 2880 1470 0 0 {name=l245 sig_type=std_logic lab=BL_6}
C {devices/lab_pin.sym} 2880 1490 0 0 {name=l246 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 3200 1280 0 0 {name=XLC_7}
C {devices/lab_pin.sym} 3120 1260 0 0 {name=l247 sig_type=std_logic lab=CSEL_7}
C {devices/lab_pin.sym} 3120 1280 0 0 {name=l248 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 3120 1300 0 0 {name=l249 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3280 1260 0 0 {name=l250 sig_type=std_logic lab=CG_7}
C {devices/lab_pin.sym} 3280 1280 0 0 {name=l251 sig_type=std_logic lab=CGB_7}
C {devices/lab_pin.sym} 3280 1300 0 0 {name=l252 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 3200 1480 0 0 {name=XPC_7}
C {devices/lab_pin.sym} 3120 1470 0 0 {name=l253 sig_type=std_logic lab=BLG_I}
C {devices/lab_pin.sym} 3120 1490 0 0 {name=l254 sig_type=std_logic lab=CG_7}
C {devices/lab_pin.sym} 3280 1470 0 0 {name=l255 sig_type=std_logic lab=BL_7}
C {devices/lab_pin.sym} 3280 1490 0 0 {name=l256 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 3600 1280 0 0 {name=XLC_8}
C {devices/lab_pin.sym} 3520 1260 0 0 {name=l257 sig_type=std_logic lab=CSEL_8}
C {devices/lab_pin.sym} 3520 1280 0 0 {name=l258 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 3520 1300 0 0 {name=l259 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3680 1260 0 0 {name=l260 sig_type=std_logic lab=CG_8}
C {devices/lab_pin.sym} 3680 1280 0 0 {name=l261 sig_type=std_logic lab=CGB_8}
C {devices/lab_pin.sym} 3680 1300 0 0 {name=l262 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 3600 1480 0 0 {name=XPC_8}
C {devices/lab_pin.sym} 3520 1470 0 0 {name=l263 sig_type=std_logic lab=BLG_I}
C {devices/lab_pin.sym} 3520 1490 0 0 {name=l264 sig_type=std_logic lab=CG_8}
C {devices/lab_pin.sym} 3680 1470 0 0 {name=l265 sig_type=std_logic lab=BL_8}
C {devices/lab_pin.sym} 3680 1490 0 0 {name=l266 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 4000 1280 0 0 {name=XLC_9}
C {devices/lab_pin.sym} 3920 1260 0 0 {name=l267 sig_type=std_logic lab=CSEL_9}
C {devices/lab_pin.sym} 3920 1280 0 0 {name=l268 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 3920 1300 0 0 {name=l269 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4080 1260 0 0 {name=l270 sig_type=std_logic lab=CG_9}
C {devices/lab_pin.sym} 4080 1280 0 0 {name=l271 sig_type=std_logic lab=CGB_9}
C {devices/lab_pin.sym} 4080 1300 0 0 {name=l272 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 4000 1480 0 0 {name=XPC_9}
C {devices/lab_pin.sym} 3920 1470 0 0 {name=l273 sig_type=std_logic lab=BLG_I}
C {devices/lab_pin.sym} 3920 1490 0 0 {name=l274 sig_type=std_logic lab=CG_9}
C {devices/lab_pin.sym} 4080 1470 0 0 {name=l275 sig_type=std_logic lab=BL_9}
C {devices/lab_pin.sym} 4080 1490 0 0 {name=l276 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} 4400 1280 0 0 {name=XLC_10}
C {devices/lab_pin.sym} 4320 1260 0 0 {name=l277 sig_type=std_logic lab=CSEL_10}
C {devices/lab_pin.sym} 4320 1280 0 0 {name=l278 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} 4320 1300 0 0 {name=l279 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 4480 1260 0 0 {name=l280 sig_type=std_logic lab=CG_10}
C {devices/lab_pin.sym} 4480 1280 0 0 {name=l281 sig_type=std_logic lab=CGB_10}
C {devices/lab_pin.sym} 4480 1300 0 0 {name=l282 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 4400 1480 0 0 {name=XPC_10}
C {devices/lab_pin.sym} 4320 1470 0 0 {name=l283 sig_type=std_logic lab=BLG_I}
C {devices/lab_pin.sym} 4320 1490 0 0 {name=l284 sig_type=std_logic lab=CG_10}
C {devices/lab_pin.sym} 4480 1470 0 0 {name=l285 sig_type=std_logic lab=BL_10}
C {devices/lab_pin.sym} 4480 1490 0 0 {name=l286 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 300 0 0 {name=XLR_0_I}
C {devices/lab_pin.sym} -380 280 0 0 {name=l287 sig_type=std_logic lab=RSEL_0}
C {devices/lab_pin.sym} -380 300 0 0 {name=l288 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 320 0 0 {name=l289 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 280 0 0 {name=l290 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} -220 300 0 0 {name=l291 sig_type=std_logic lab=RGB_0_I}
C {devices/lab_pin.sym} -220 320 0 0 {name=l292 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 300 0 0 {name=XPR_0_I}
C {devices/lab_pin.sym} -80 290 0 0 {name=l293 sig_type=std_logic lab=PL_0_I}
C {devices/lab_pin.sym} -80 310 0 0 {name=l294 sig_type=std_logic lab=WL_0_I}
C {devices/lab_pin.sym} 80 290 0 0 {name=l295 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 310 0 0 {name=l296 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 520 0 0 {name=XLR_1_I}
C {devices/lab_pin.sym} -380 500 0 0 {name=l297 sig_type=std_logic lab=RSEL_1}
C {devices/lab_pin.sym} -380 520 0 0 {name=l298 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 540 0 0 {name=l299 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 500 0 0 {name=l300 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} -220 520 0 0 {name=l301 sig_type=std_logic lab=RGB_1_I}
C {devices/lab_pin.sym} -220 540 0 0 {name=l302 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 520 0 0 {name=XPR_1_I}
C {devices/lab_pin.sym} -80 510 0 0 {name=l303 sig_type=std_logic lab=PL_1_I}
C {devices/lab_pin.sym} -80 530 0 0 {name=l304 sig_type=std_logic lab=WL_1_I}
C {devices/lab_pin.sym} 80 510 0 0 {name=l305 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 530 0 0 {name=l306 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 740 0 0 {name=XLR_2_I}
C {devices/lab_pin.sym} -380 720 0 0 {name=l307 sig_type=std_logic lab=RSEL_2}
C {devices/lab_pin.sym} -380 740 0 0 {name=l308 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 760 0 0 {name=l309 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 720 0 0 {name=l310 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} -220 740 0 0 {name=l311 sig_type=std_logic lab=RGB_2_I}
C {devices/lab_pin.sym} -220 760 0 0 {name=l312 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 740 0 0 {name=XPR_2_I}
C {devices/lab_pin.sym} -80 730 0 0 {name=l313 sig_type=std_logic lab=PL_2_I}
C {devices/lab_pin.sym} -80 750 0 0 {name=l314 sig_type=std_logic lab=WL_2_I}
C {devices/lab_pin.sym} 80 730 0 0 {name=l315 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 750 0 0 {name=l316 sig_type=std_logic lab=VSS}
C {ls_hv06.sym} -300 960 0 0 {name=XLR_3_I}
C {devices/lab_pin.sym} -380 940 0 0 {name=l317 sig_type=std_logic lab=RSEL_3}
C {devices/lab_pin.sym} -380 960 0 0 {name=l318 sig_type=std_logic lab=VDDL}
C {devices/lab_pin.sym} -380 980 0 0 {name=l319 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -220 940 0 0 {name=l320 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} -220 960 0 0 {name=l321 sig_type=std_logic lab=RGB_3_I}
C {devices/lab_pin.sym} -220 980 0 0 {name=l322 sig_type=std_logic lab=VDDH_I}
C {pg_n06.sym} 0 960 0 0 {name=XPR_3_I}
C {devices/lab_pin.sym} -80 950 0 0 {name=l323 sig_type=std_logic lab=PL_3_I}
C {devices/lab_pin.sym} -80 970 0 0 {name=l324 sig_type=std_logic lab=WL_3_I}
C {devices/lab_pin.sym} 80 950 0 0 {name=l325 sig_type=std_logic lab=PLG_I}
C {devices/lab_pin.sym} 80 970 0 0 {name=l326 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} -2000 100 0 0 {name=p327 lab=RSEL_0}
C {devices/ipin.sym} -2000 130 0 0 {name=p328 lab=RSEL_1}
C {devices/ipin.sym} -2000 160 0 0 {name=p329 lab=RSEL_2}
C {devices/ipin.sym} -2000 190 0 0 {name=p330 lab=RSEL_3}
C {devices/ipin.sym} -2000 220 0 0 {name=p331 lab=CSEL_0}
C {devices/ipin.sym} -2000 250 0 0 {name=p332 lab=CSEL_1}
C {devices/ipin.sym} -2000 280 0 0 {name=p333 lab=CSEL_2}
C {devices/ipin.sym} -2000 310 0 0 {name=p334 lab=CSEL_3}
C {devices/ipin.sym} -2000 340 0 0 {name=p335 lab=CSEL_4}
C {devices/ipin.sym} -2000 370 0 0 {name=p336 lab=CSEL_5}
C {devices/ipin.sym} -2000 400 0 0 {name=p337 lab=CSEL_6}
C {devices/ipin.sym} -2000 430 0 0 {name=p338 lab=CSEL_7}
C {devices/ipin.sym} -2000 460 0 0 {name=p339 lab=CSEL_8}
C {devices/ipin.sym} -2000 490 0 0 {name=p340 lab=CSEL_9}
C {devices/ipin.sym} -2000 520 0 0 {name=p341 lab=CSEL_10}
C {devices/iopin.sym} -1800 100 0 0 {name=p342 lab=BLG_I}
C {devices/iopin.sym} -1800 130 0 0 {name=p343 lab=PLG_I}
C {devices/ipin.sym} -1800 160 0 0 {name=p344 lab=VDDH_I}
C {devices/ipin.sym} -1800 190 0 0 {name=p345 lab=VDDL}
C {devices/ipin.sym} -1800 220 0 0 {name=p346 lab=VSS}
T {band_i: rows 0-3, cols 0-10 of the 32x32 array} -2000 0 0 0 0.8 0.8 {}
